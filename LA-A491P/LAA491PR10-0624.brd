# Allegro board LAA491PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDCA0_2: length 30.2
  TOP w0.127: UV5.C2 173.81,152.05 174.2,152.44 175.33,152.44 175.53,152.24 176.52,152.24 177.07,151.69 177.91,151.69 178.03,151.56 178.03,151.23 177.91,151.1 177.32,151.1 177.19,150.98 177.19,150.63 177.32,150.51 177.91,150.51 178.03,150.38 178.03,150.06 177.91,149.93 v2(177.89,149.93) 177.32,149.93 177.19,149.81 177.19,149.47 177.32,149.35 177.91,149.35 178.03,149.22 178.03,139.53 v1(174.84,136.34)
  BOTTOM w0.102: 174.68,133.74 174.68,133.64 174.66,133.63 174.66,133.41 174.78,133.29 174.78,132.92 174.76,132.9 174.76,132.54 174.77,132.53 174.77,132.08 174.59,131.9 174.59,131.76 174.72,131.64 174.97,131.64 175.06,131.73 UV1.D25
  BOTTOM w0.127: 174.68,133.74 174.68,135.1 175.16,135.58 175.16,136.03 v1(174.84,136.34)
EDCA0_3: length 15.3
  BOTTOM w0.102: 178.17,135.19 178.98,134.37 178.98,133.44 178.76,133.22 178.76,132.91 179.07,132.59 179.22,132.59 179.37,132.45 179.37,132.08 179.24,131.96 178.97,131.96 178.84,131.83 178.84,131.62 178.97,131.49 UV1.E20
  BOTTOM w0.127: UV4.R13 173.72,143.25 174.13,142.84 174.51,142.84 174.72,142.63 v2(174.72,140.57) 174.72,140.25 177.7,137.27 177.7,135.65 178.17,135.19
EDCA1_0: length 13.4
  TOP w0.102: v1(181.96,131.9) 181.45,132.41 181.45,132.79 181.82,133.16 182.05,133.16 183.88,135 183.88,135.39
  TOP w0.127: UV3.R13 183.99,142.78 183.99,137.82 183.88,137.71 v2(183.88,137.23) 183.88,135.39
  BOTTOM w0.102: UV1.E16 182.26,131.59 v1(181.96,131.9)
EDCA1_1: length 29.8
  BOTTOM w0.102: UV1.E12 185.46,131.51 186.01,132.06 186.01,132.48 185.96,132.53 185.96,132.84 185.97,132.85 185.97,133.4 185.71,133.66 185.71,135.39
  BOTTOM w0.127: UV6.C2 184.12,151.98 183.75,152.35 181.72,152.35 180.13,150.76 180.13,141.79 v2(180.72,141.2) 181.12,140.8 181.12,140.62 180.95,140.45 180.95,140.3 181.16,140.09 181.31,140.09 181.51,140.29 181.63,140.29 181.87,140.05 181.87,139.93 181.69,139.74 181.69,139.56 181.87,139.39 182.04,139.39 182.2,139.54 182.38,139.54 182.56,139.36 182.56,139.18 182.4,139.03 182.4,138.85 182.58,138.67 182.76,138.67 182.92,138.82 183.1,138.82 183.28,138.64 183.28,138.46 183.12,138.31 183.12,138.13 183.3,137.95 183.48,137.95 183.64,138.1 183.82,138.1 184,137.92 184,137.75 183.84,137.59 183.84,137.41 185.71,135.54 185.71,135.39
EDCA1_2: length 39
  TOP w0.102: v1(186.88,128.69) 186.88,129.18 188.5,130.79 188.5,130.88
  TOP w0.127: UV3.C2 194.32,151.98 194.71,152.38 195.85,152.38 196.04,152.18 196.5,152.18 196.63,152.31 196.63,152.6 196.75,152.73 197.01,152.73 197.13,152.6 197.13,152.31 197.26,152.18 197.51,152.18 197.64,152.05 197.64,150.06 197.77,149.93 198.15,149.93 198.28,150.06 198.28,150.9 198.4,151.02 198.8,151.02 198.93,150.9 198.93,141.04 v2(196.38,138.49) 193.01,135.12 189.24,135.12 188.5,134.38 188.5,130.88
  BOTTOM w0.102: v1(186.88,128.69) 187.26,128.31 UV1.J10
EDCA1_3: length 16
  BOTTOM w0.102: UV1.D7 189.48,131.89 189.97,132.38 189.97,132.88 189.96,132.89 189.96,133.22 190.14,133.4 190.14,133.73 190.15,133.74 190.15,133.77
  BOTTOM w0.127: UV6.R13 194.23,143.18 194.64,142.78 195.02,142.78 195.23,142.57 195.23,140.45 195.1,140.33 194.97,140.33 194.85,140.2 194.85,139.95 194.97,139.82 195.1,139.82 195.23,139.69 195.23,139.44 195.1,139.31 194.97,139.31 194.85,139.18 194.85,138.93 194.97,138.8 195.1,138.8 195.23,138.68 v2(195.23,138.08) 192.54,135.39 191.73,135.39 190.15,133.81 190.15,133.77
EDCB0_0: length 21.4
  TOP w0.102: 194.39,130.49 194.21,130.49 194.21,130.5 193.96,130.76 193.41,130.76 192.78,131.38 192.22,131.38 192.18,131.34 192.18,131.34 191.74,130.91 v1(191.01,130.91)
  TOP w0.127: 194.39,130.49 195.68,130.49 v2(199.86,134.67) 201.84,136.65 202.02,136.65 202.33,136.34 202.51,136.34 202.69,136.52 202.69,136.7 202.38,137.01 202.38,137.19 202.56,137.37 202.74,137.37 203.01,137.11 203.19,137.11 203.37,137.29 203.37,137.47 203.1,137.73 203.1,137.91 203.43,138.24 203.58,138.24 203.69,138.12 203.8,138.12 203.99,138.31 205.39,138.31 205.56,138.14 UV7.R13
  BOTTOM w0.102: v1(191.01,130.91) 190.81,130.91 190.59,130.69 190.46,130.69 UV1.F6
EDCB0_1: length 38.4
  BOTTOM w0.102: 194.39,128.1 194.2,128.1 193.7,127.59 192.74,127.59 192.43,127.29 UV1.K3
  BOTTOM w0.127: 194.39,128.1 194.67,128.1 v2(195.11,128.54) 196.94,130.38 196.94,131.84 197.07,131.97 197.35,131.97 197.48,132.1 197.48,132.35 197.35,132.48 197.11,132.48 196.98,132.61 196.98,132.86 197.11,132.99 197.35,132.99 197.48,133.11 197.48,133.37 197.35,133.5 197.11,133.5 196.98,133.62 196.98,133.88 197.11,134 197.35,134 197.48,134.13 197.48,134.95 199.51,136.99 199.51,138.09 203.35,141.93 207.7,141.93 208.04,141.6 214.25,141.6 214.67,141.17 214.68,141.17 215.94,139.91 215.94,138.77 215.48,138.31 214.98,138.31 214.57,137.91 UV8.C2
EDCB0_2: length 15.9
  BOTTOM w0.102: UV1.P3 192.16,123.99 192.53,123.99 192.74,123.79 193.01,123.79 193.14,123.91 194.39,123.91
  BOTTOM w0.127: 194.39,123.91 v2(195.17,123.91) 196.98,123.91 199.57,126.5 201.99,126.5 202.16,126.67 203.18,126.67 203.58,127.07 204.94,127.07 205.15,127.28 205.15,127.66 205.56,128.07 UV8.R13
EDCB0_3: length 31
  TOP w0.127: v1(193.39,120.98) 193.76,121.35 194.46,121.35 196.86,123.76 v2(202.51,123.76) 211.16,123.76 211.29,123.88 211.29,124.53 211.42,124.66 211.69,124.66 211.82,124.53 211.82,123.88 211.94,123.76 212.2,123.76 212.33,123.88 212.33,124.53 212.45,124.66 212.71,124.66 212.83,124.53 212.83,124.41 212.96,124.28 213.21,124.28 213.34,124.41 213.34,124.53 213.47,124.66 213.69,124.66 214.55,125.53 214.55,126.26 214.75,126.46 214.75,127.59 214.36,127.98 UV7.C2
  BOTTOM w0.102: v1(193.39,120.98) 192.96,120.55 192.74,120.55 192.62,120.68 192.3,120.68 192.15,120.52 191.63,120.52 UV1.V5
EDCB1_0: length 31.8
  BOTTOM w0.102: 194.39,118.25 194,118.25 193.12,117.37 192.74,117.37 192.68,117.44 192.25,117.44 192.01,117.19 191.72,117.19 191.54,117.37 191.54,117.51 191.73,117.7 191.73,117.84 191.61,117.97 191.29,117.97 191.23,117.91 191.23,117.73 UV1.AB5
  BOTTOM w0.127: 194.39,118.25 197.48,118.25 198.26,119.02 201.2,121.96 v2(211.14,121.96) 213.3,121.96 214.48,120.77 214.49,120.77 215.75,119.51 215.75,118.37 215.29,117.92 214.79,117.92 214.38,117.51 UV10.C2
EDCB1_1: length 15.1
  TOP w0.127: UV9.R13 204.97,117.91 203.36,117.91 203.05,118.21 199.52,118.21 v2(199.24,117.93) 195.47,114.16 v1(195.47,113.93)
  BOTTOM w0.102: UV1.AH1 192.98,113 194.07,113 194.12,113.05 194.39,113.05
  BOTTOM w0.127: 194.39,113.05 194.59,113.05 v1(195.47,113.93)
EDCB1_2: length 40
  TOP w0.102: v1(187.65,111.5) 188.26,112.11 189.95,112.11 190.03,112.2 191.04,112.2 191.74,111.5
  TOP w0.127: 191.74,111.5 191.74,109.13 192.97,107.9 197.4,107.9 202.32,102.98 v2(204.68,102.98) 212.94,102.98 213.07,103.11 213.07,103.83 213.19,103.96 213.45,103.96 213.58,103.83 213.58,103.76 213.71,103.63 213.96,103.63 214.09,103.76 214.09,104.7 214.21,104.83 215.16,104.83 215.29,104.96 215.29,105.21 215.16,105.34 214.49,105.34 214.36,105.47 214.36,105.86 214.56,106.06 214.56,107.26 214.24,107.58 214.24,107.84 UV9.C2
  BOTTOM w0.102: v1(187.65,111.5) 187.65,111.68 UV1.AJ9
EDCB1_3: length 16.2
  BOTTOM w0.102: UV1.AM5 191.59,109.36 192.43,109.36 192.6,109.18 193.49,109.18 193.91,108.76 194.39,108.76
  BOTTOM w0.127: UV10.R13 205.37,107.74 205.01,107.38 205.01,106.93 204.77,106.69 203.33,106.69 202.81,107.21 v2(201.15,107.21) 199.87,107.21 198.32,108.76 194.39,108.76
EDID_CLK: length 28.6
  TOP w0.102: UX4.46 202.92,174.05 202.99,174.13 202.99,174.79 203.05,174.84 203.05,175.83 202.28,176.6 v3(201.98,176.6) 201.42,176.6 201.25,176.43 v1(201.26,176.43) 201.07,176.61 200.67,176.61 200.54,176.47 RP56.3
  BOTTOM w0.102: JLVDS.34 220.95,174.25 221.09,174.38 221.09,175.64 220.5,176.22 216.25,176.22 215.84,176.63 201.46,176.63 v1(201.26,176.43)
EDID_DATA: length 29.3
  TOP w0.102: RP56.4 200.54,176.97 200.67,176.84 201.08,176.84 v1(201.26,177.01) 201.25,177.01 201.42,176.83 202.37,176.83 203.28,175.92 v3(203.28,175.49) 203.28,174.75 203.22,174.69 203.22,174.13 203.32,174.03 UX4.45
  BOTTOM w0.102: JLVDS.35 221.45,174.25 221.31,174.38 221.31,175.73 220.6,176.45 216.34,176.45 215.94,176.86 201.41,176.86 v1(201.26,177.01)
EDP_AUX: length 5.4
  BOTTOM w0.102: RX39.2 202.24,171.67 v3(203.36,171.67) 204.06,171.67 205.16,170.57 205.88,170.57 206.03,170.72 206.18,170.72 RX40.1
EDP_AUX#: length 5.4
  BOTTOM w0.102: RX37.2 202.24,171.94 204.18,171.94 v3(204.78,171.33) 205.27,170.84 205.77,170.84 205.92,170.99 206.26,170.99 RX38.1
EDP_BIA_PWM: length 144.7
  TOP w0.102: v1(205.38,166.46) 205.32,166.52 UX4.21
  IN1 w0.127: v1(101.69,130.63) 102.49,131.42 102.99,131.42 105.25,133.68 108.68,133.68 109.21,134.21 109.21,134.42 109.61,134.82 112.78,134.82 114.75,136.79 118.19,136.79 119.45,138.05 128.33,138.05 129.33,137.05 133.24,137.05 v1(134.59,135.7)
  IN3 w0.127: v1(205.38,166.46) 205.22,166.3 205.22,165.72 205.43,165.51 205.43,163.12 203.25,160.94 190.94,160.94 188.92,158.92 161.81,158.92 160.65,157.76 160.65,153.83 158.92,152.11 158.92,141.29 151.68,134.05 149.25,134.05 148.16,135.14 135.15,135.14 v1(134.59,135.7)
  BOTTOM w0.102: RX36.1 RX49.1 205.24,165.66 205.24,166.31 v1(205.38,166.46) ; v1(101.69,130.63) 102.09,130.63 v2(102.32,130.4) 103.08,129.64 RC72.2 ; RC81.2 129.63,134.83 129.66,134.81 RC75.2 130.13,135.7 130.59,136.15 134.13,136.15 v1(134.59,135.7)
EDP_BKLCTL: length 10.6
  BOTTOM w0.076: UC1.B8 125.45,124.98 125.45,125.8 126.75,127.11 126.75,128.13 128.64,130.01 128.64,131.46
  BOTTOM w0.089: 128.64,131.46 128.64,132.12 v2(129.07,132.55) 129.25,132.74
  BOTTOM w0.102: RC81.1 129.25,132.74
EDP_COMP: length 2.9
  TOP w0.089: v1(119.65,123.23) 119.65,123.73 v2(119.91,123.99)
  TOP w0.508: RC71.2 118.77,124.03 119.04,123.76 119.04,123.76 119.57,123.23 v1(119.65,123.23)
  BOTTOM w0.254: v1(119.65,123.23) 119.27,123.61 UC1.D20
EDP_CPU_AUX: length 137.6
  TOP w0.102: v1(190.64,158.82) 190.47,159 190.47,160.6 191.29,161.43 191.29,166.48 196.37,171.56 197.17,171.56 RX25.1 197.83,171.31 197.83,171.46 198.01,171.64 198.15,171.64 CX43.1
  IN1 w0.127: v1(190.64,158.82) 190.47,158.65 190.47,158.25 189.74,157.53 165.53,157.53 164.92,156.92 157.19,156.92 154.93,154.66 154.93,152.66 158.34,149.25 158.34,140.25 153.36,135.27 149.52,135.27 148.67,134.41 138.04,134.41 136.81,133.18 132.2,133.18 131.96,133.42 129.3,133.42 127.39,135.33 120.73,135.33 119.68,134.28 116.65,134.28 113.52,131.16 110.14,131.16 108.8,129.82 105.58,129.82 103.48,127.72 102.92,127.72 102.77,127.57 102.77,127.56 v1(102.76,127.56)
  BOTTOM w0.076: UC1.B45 103.03,125.15 102.73,125.44 102.73,126.37 103.15,126.79 103.15,127.63 103.07,127.71 102.91,127.71 v1(102.76,127.56)
EDP_CPU_AUX#: length 137.5
  TOP w0.102: v1(190.05,158.82) 190.25,159.02 190.25,160.69 191.08,161.52 191.08,166.57 196.28,171.78 197.06,171.78 RX30.2 197.63,172.3 198.07,171.85 198.21,171.85 CX44.1
  IN1 w0.127: v1(102.77,128.19) 102.96,127.99 103.37,127.99 105.47,130.09 108.68,130.09 110.02,131.43 113.41,131.43 116.54,134.55 119.57,134.55 120.62,135.6 127.51,135.6 129.41,133.7 132.07,133.7 132.31,133.45 136.7,133.45 137.92,134.68 148.55,134.68 149.41,135.54 153.24,135.54 158.07,140.36 158.07,149.14 154.66,152.55 154.66,154.77 157.08,157.19 164.81,157.19 165.42,157.8 189.63,157.8 190.19,158.37 190.19,158.68 v1(190.05,158.82)
  BOTTOM w0.076: UC1.A45 103.18,125.56 103.27,125.65 103.27,125.77 102.93,126.12 102.93,126.29 103.34,126.71 103.34,127.71 103.15,127.9 102.92,127.9 102.77,128.05 v1(102.77,128.19)
EDP_CPU_HPD: length 102.1
  TOP w0.102: v1(199.3,173.11) 200.24,173.11 200.78,172.58 UX4.1
  IN3 w0.127: v1(133.76,135.71) 134.2,136.15 134.9,136.15 135.5,135.56 150.32,135.56 158.11,143.34 158.11,152.46 159.86,154.22 159.86,158.25 161.36,159.75 188.5,159.75 195.36,166.61 195.36,170.57 196.69,171.9 198.72,171.9 199.3,172.49 v1(199.3,173.11)
  BOTTOM w0.102: v1(133.76,135.71) 133.66,135.61 QC3.2 133.66,131.52 RC105.1 ; v1(199.3,173.11) 198.86,172.67 RX35.1 RX52.1
EDP_CPU_LANE_N0: length 141.3
  TOP w0.102: CX46.1 198.33,169.68 195.48,169.68 191.99,166.19 191.99,161.07 191.67,160.75 191.67,160.16 v1(191.7,160.13)
  IN1 w0.084: 101.49,129.92 101.03,129.92
  IN1 w0.127: 101.49,129.92 101.71,129.92 102.1,130.32 103.13,130.32 104.67,131.85 107.62,131.85 109.57,133.8 113.2,133.8 115.68,136.28 118.4,136.28 119.66,137.54 128.12,137.54 129.12,136.54 132.31,136.54 133.57,135.28 136.1,135.28 137.09,136.27 147.76,136.27 148.69,137.21 152.35,137.21 156.42,141.27 156.42,147.34 153,150.76 153,156.84 155.98,159.81 188.02,159.81 189.1,160.89 191.26,160.89 191.6,160.55 191.6,160.23 v1(191.7,160.13) ; 101.03,129.92 v1(100.86,130.09)
  BOTTOM w0.076: 102.06,128.59 102.06,126.98 102.57,126.47 102.57,124.95 102.76,124.77 102.76,124.53 UC1.C45
  BOTTOM w0.102: 102.06,128.59 102.07,128.61 102.07,129.23 101.44,129.87 101.09,129.87 v1(100.86,130.09)
EDP_CPU_LANE_N1: length 139.3
  TOP w0.102: CX39.1 196.32,168.73 195.52,168.73 192.75,165.96 192.75,160.04 192.35,159.64 192.35,159.13 v1(192.72,158.76)
  IN1 w0.127: v1(100.86,128.19) 101.03,128.02 101.37,128.02 101.93,128.58 101.93,129.03 102.44,129.54 103.53,129.54 104.88,130.88 108.08,130.88 109.43,132.24 112.78,132.24 115.96,135.42 119.09,135.42 120.41,136.74 127.58,136.74 129.82,134.51 132.73,134.51 132.93,134.31 136.31,134.31 137.48,135.47 148.22,135.47 149.12,136.37 152.68,136.37 157.24,140.93 157.24,148.8 153.88,152.17 153.88,156.5 156.41,159.03 188.51,159.03 189.08,159.6 192.27,159.6 192.58,159.29 192.58,158.9 v1(192.72,158.76)
  BOTTOM w0.076: UC1.A47 101.74,125.72 101.74,125.83 101.81,125.89 101.93,125.89 102,125.96 102,126.07 101.89,126.18 100.61,126.18 100.23,126.57 100.23,127.72 100.52,128.01 100.68,128.01 v1(100.86,128.19)
EDP_CPU_LANE_P0: length 141.2
  TOP w0.102: v1(191.12,160.13) 191.46,160.47 191.46,160.84 191.77,161.16 191.77,166.28 195.39,169.9 198.04,169.9 CX42.1
  IN1 w0.127: v1(100.86,129.46) 101.06,129.65 101.82,129.65 102.21,130.05 103.24,130.05 104.78,131.58 107.73,131.58 109.68,133.53 113.31,133.53 115.79,136.01 118.52,136.01 119.78,137.27 128,137.27 129.01,136.27 132.2,136.27 133.46,135.01 136.21,135.01 137.2,136 147.87,136 148.81,136.94 152.47,136.94 156.69,141.16 156.69,147.45 153.27,150.87 153.27,156.73 156.09,159.54 188.14,159.54 189.21,160.61 191.15,160.61 191.33,160.43 191.33,160.34 v1(191.12,160.13)
  BOTTOM w0.076: UC1.B46 102.34,124.46 102.19,124.46 102.12,124.52 102.12,124.72 102.38,124.98 102.38,126.39 101.87,126.9 101.87,128.5 101.86,128.51 101.86,128.68
  BOTTOM w0.102: v1(100.86,129.46) 101.06,129.65 101.35,129.65 101.86,129.14 101.86,128.68
EDP_CPU_LANE_P1: length 139.4
  TOP w0.102: v1(192.14,158.76) 192.14,159.73 192.54,160.13 192.54,166.05 195.44,168.96 196.5,168.96 CX38.1
  IN1 w0.127: v1(192.14,158.76) 192.31,158.93 192.31,159.18 192.16,159.33 189.2,159.33 188.62,158.76 156.52,158.76 154.15,156.39 154.15,152.28 157.51,148.92 157.51,140.81 152.79,136.1 149.24,136.1 148.33,135.2 137.59,135.2 136.43,134.03 132.82,134.03 132.62,134.24 129.71,134.24 127.47,136.47 120.53,136.47 119.2,135.15 116.08,135.15 112.89,131.96 109.55,131.96 108.19,130.61 104.99,130.61 103.64,129.26 102.55,129.26 102.2,128.92 102.2,128.47 101.48,127.75 101.06,127.75 v1(100.86,127.55)
  BOTTOM w0.076: UC1.B47 101.9,125.15 102.19,125.44 102.19,126.15 101.97,126.38 100.69,126.38 100.42,126.64 100.42,127.65 100.6,127.82 100.8,127.82 100.86,127.75 v1(100.86,127.55)
EDP_DISP_UTIL: length 3.6
  BOTTOM w0.102: UC1.A43 103.66,126.31 v2(103.66,127.54) 103.66,128.41 RC72.1
EDP_HPD_PANEL: length 21.3
  TOP w0.102: v1(196.9,179.41) 197.27,179.78 199.41,179.78 v2(200.54,178.65) 200.93,178.25 207.5,178.25 208.74,177.01 RX53.1
  BOTTOM w0.102: v1(196.9,179.41) 196.9,172.2 197.32,171.78 RX52.2
EDP_N0: length 5.3
  BOTTOM w0.102: RX44.1 206.23,168.9 205.98,168.9 205.21,169.66 v3(203.55,169.66) 203.26,169.66 203.02,169.89 202.24,169.89 RX43.2
EDP_N1: length 5.3
  BOTTOM w0.102: RX48.1 206.2,167.14 204.95,167.14 203.98,168.11 v3(203.71,168.11) 202.24,168.11 RX47.2
EDP_P0: length 5.3
  BOTTOM w0.102: RX42.1 206.21,169.16 206.09,169.16 205.32,169.92 v3(205.07,169.92) 203.37,169.92 203.13,170.16 202.24,170.16 RX41.2
EDP_P1: length 5.2
  BOTTOM w0.102: RX45.2 202.24,168.38 204.09,168.38 205.06,167.41 v3(205.41,167.41) 206.24,167.41 RX46.1
EN_0.675VSP: length 5.1
  BOTTOM w0.102: PR202.2 162.01,27.73 162.43,28.16 162.43,28.48 v2(162.62,28.67)
  BOTTOM w0.203: PU200.7 160.49,25.23 161.38,26.11 PC203.1
  BOTTOM w0.254: PC203.1 PR202.2
EN_1.35V: length 3
  BOTTOM w0.203: PR201.2 161.42,25.22 v1(161.08,24.88) 161.03,24.83 PU200.8
  BOTTOM w0.254: PC202.1 PR201.2
EN_+1.2VSP: length 3.9
  TOP w0.102: PR1103.2 190.91,172.27 v2(191.07,172.11)
  TOP w0.254: PR1103.2 189.14,172.27 v1(189.13,172.29) PU1100.3
  BOTTOM w0.254: v1(189.13,172.29) 189.03,172.18 188.93,172.18 188.78,172.03 PC1104.1
EN_DFAN1: length 192.9
  TOP w0.102: v1(193.34,50.13) 193.59,50.37 UE1.70
  IN3 w0.127: v1(193.34,50.13) 193.34,50.11 192.15,48.91 189.63,48.91 188.02,50.53 183.26,50.53 181.76,49.03 176.46,49.03 175.85,48.41 141.21,48.41 140.75,47.95 115.77,47.95 114.7,49.03 69.51,49.03 61.44,57.1 61.44,72.6 59.3,74.74 59.3,92.49 56.1,95.68 56.1,97.29 54.77,98.63 v1(54.77,102.31)
  BOTTOM w0.102: v1(54.77,102.31) v2(53.79,102.31) 50.19,102.31 50.07,102.44 UE3.4
EN_INVPWR: length 166.5
  TOP w0.102: UE1.68 194.39,49.85 v1(194.78,49.45) ; QX1.2 216.44,175.93 216.44,174.83 v1(216.18,174.57)
  IN2 w0.127: v1(217.1,51.75) 217.86,52.52 217.86,53.34 222.91,58.39 222.91,71.3 228.81,77.2 228.81,85.95 225.82,88.95 225.82,95.92 228.81,98.91 228.81,107.29 224.95,111.16 224.95,120.7 225.85,121.6 225.85,146.25 216.79,155.3 216.79,166.51 215.61,167.69 215.61,174 v1(216.18,174.57)
  BOTTOM w0.102: v1(194.78,49.45) 198.84,49.45 199.72,48.57 200.92,48.57 200.98,48.51 213,48.51 v2(215.19,50.7) 215.61,51.13 215.61,51.61 216.14,52.14 216.71,52.14 v1(217.1,51.75)
EN_PCIE: length 1
  BOTTOM w0.102: PR1304.1 v2(198.93,65.11)
ENVDD_PCH: length 237.5
  TOP w0.089: RC87.2 126.85,124.61 v1(127.01,124.45)
  TOP w0.102: UE1.19 190.39,36.95 v1(190.33,37.01)
  IN1 w0.127: v1(128.49,127.9) 128.81,127.58 131.98,127.58 133.32,128.92 136.24,128.92 139.59,132.27 143.92,132.27 v1(150.32,125.86) 152.61,123.57 152.61,119.63 157.2,115.03 157.2,113.28 161.15,109.33 161.15,104.07 164.18,101.05 164.18,100.49 v1(169.4,95.26) ; v1(190.33,37.01) 190.46,37.01 190.85,37.4 190.85,37.75 192.42,39.33 192.42,44.84 192.08,45.18 192.08,47.21 192.42,47.54 192.42,50.56 192.56,50.7 192.56,54.29 191.86,54.99 191.86,56.02 190.37,57.51 190.37,64.55 189.3,65.62 189.3,75.66 182.7,82.26 178.68,82.26 174.33,86.6 167.87,86.6 v1(165.78,88.69)
  IN3 w0.127: v1(208.25,163.65) 208.19,163.65 205.23,160.68 191.04,160.68 189.03,158.66 161.91,158.66 160.9,157.65 160.9,153.58 159.28,151.97 159.28,141.19 152.19,134.09 v1(152.19,133.17)
  BOTTOM w0.089: v1(127.01,124.45) 126.92,124.36 UC1.C6 126.5,124.77 126.91,125.18 127.03,125.3 127.03,125.97 128.49,127.43 v1(128.49,127.9)
  BOTTOM w0.102: v1(169.4,95.26) 168.24,94.1 v2(168.24,92.56) 168.24,91.16 v1(165.78,88.69) ; v1(208.25,163.65) 207.56,164.34 RX51.1 ; v1(150.32,125.86) 150.32,131.31 v1(152.19,133.17)
ENVDD_R: length 3.9
  TOP w0.102: UX1.3 217.58,167.53 RX7.1 RX8.1 215.58,166.84 v2(214.82,166.08)
ERP_LOT6: length 165.1
  TOP w0.102: v1(193.31,55.57) 192.94,55.2 192.94,53.16 192.39,52.6 UE1.73
  TOP w0.254: PQ1.2 128.87,172.37 PC5.1 PR1.2 PR2.1 v1(130.09,171.73)
  IN2 w0.127: v1(186.26,58) 185.75,58.51 185.75,65.66 186.52,66.43 186.52,73.94 183.31,77.15 183.31,78.17 182.66,78.82 182.46,78.82 160.6,100.69 158.03,100.69 153.37,105.35 153.37,107.91 152.78,108.5 152.78,109.68 152.43,110.03 152.43,111.1 151.32,112.2 151.32,114.44 148.53,117.23 144.47,117.23 143.51,118.19 143.51,120.75 136.87,127.39 136.87,138.48 126.65,148.7 v1(124.48,148.7)
  IN3 w0.127: v1(130.09,171.73) 128.92,171.73 126.9,169.71 126.9,158.47 124.48,156.04 v1(124.48,148.7)
  BOTTOM w0.102: v1(186.26,58) 186.49,58.23 190.66,58.23 v1(193.31,55.57)
F-IMAX: length 4.3
  TOP w0.102: v2(87.06,141.23) 86.83,141.01 v1(86.83,140.6)
  TOP w0.254: v1(86.83,140.6) 86.71,140.47 PR505.2
  BOTTOM w0.203: v1(86.83,140.6) 87.29,140.14 87.96,140.14 88.22,139.88 PU501.10
  BOTTOM w0.254: PR504.1 v1(86.83,140.6)
FAN_SPEED1: length 210.2
  TOP w0.102: UE1.28 193.99,34.36 193.96,34.34 CE29.1 194.59,33.11 194.59,32.01 193.47,30.9 181.7,30.9 179.7,32.9 179.7,34.78 179.32,35.15 179.29,35.19 174.23,40.24 170.58,40.24 169.19,41.63 169.19,46.49 v1(168.2,47.48) ; v2(52,103.66) v1(51.38,103.66)
  IN3 w0.127: v1(51.38,103.66) 51.38,99.29 58.51,92.16 58.51,74.42 60.64,72.29 60.64,56.66 69.47,47.83 114.82,47.83 115.45,47.19 141.07,47.19 141.36,47.48 v1(168.2,47.48)
  BOTTOM w0.102: v1(51.38,103.66) 50.05,104.99 RE50.2 CE24.1 49.94,106.23 JFAN.2
FB_1.5VSP: length 4.3
  BOTTOM w0.102: PC404.2 v2(113.68,22.6)
  BOTTOM w0.254: PC404.2 PR403.2 PR402.1 111.02,23.78 110.87,23.93 PU400.1
FB_1.8VSP: length 4.7
  BOTTOM w0.102: PC604.2 220.15,88.02 v2(220.08,87.95)
  BOTTOM w0.254: PC604.2 PR603.2 221.25,89.77 PR602.1 220.68,89.79 220.5,89.61 220.25,89.61 220.04,89.81 PU600.1
FB_1.35V: length 5.3
  BOTTOM w0.102: PR204.1 v2(161.47,30.17)
  BOTTOM w0.203: PU200.6 160.39,25.63 160.55,25.79 160.55,26.93 161.47,27.85 PR207.1
  BOTTOM w0.254: PR204.1 PR207.1
FB_3V: length 3.6
  TOP w0.203: 128.54,13.68 128.23,13.99 PU100.4
  TOP w0.254: 128.54,13.68 128.93,13.28 PR109.2 PC102.2 PR107.2
FB_5V: length 4.3
  TOP w0.203: v3(126.74,13.63) 127.05,13.63 127.43,14.01 PU100.2
  TOP w0.254: PR104.1 126.71,13.6 v3(126.74,13.63)
  BOTTOM w0.102: v3(126.74,13.63) 126.74,14.1 v2(126.87,14.24)
  BOTTOM w0.254: PR106.1 PC108.1 126.67,13.55 126.74,13.62 v3(126.74,13.63)
FB_+1.2VSP: length 3.9
  TOP w0.254: v1(189.13,172.87) 189.13,172.79 PU1100.4
  BOTTOM w0.102: v2(190.93,173.23) 190.57,172.87 PR1107.1
  BOTTOM w0.254: PR1107.1 v1(189.13,172.87) 189.08,172.92 PR1108.1
FB_PCIE: length 4.7
  TOP w0.254: PC1306.2 PR1302.2 196.88,62.57 v1(196.3,61.99) 195.99,62.29 PR1301.1
  BOTTOM w0.102: v2(197.04,63) 196.3,62.25 v1(196.3,61.99)
  BOTTOM w0.254: v1(196.3,61.99) 196.08,61.99 195.66,62.4 PU1300.6
GCLK_VRTC: length 3.8
  TOP w0.102: UG1.10 72.63,43.63 73.43,44.44 CG5.1 74.57,44.44 RG1.2
GENLK_CLK: length 2.5
  TOP w0.102: v1(171.24,116.23) 170.68,116.79 T80.1
  BOTTOM w0.102: UV1.AD29 171.66,115.81 v1(171.24,116.23)
GENLK_VSYNC: length 1.5
  TOP w0.102: T81.1 171.51,117.18 v1(171.51,117.48)
  BOTTOM w0.102: v1(171.51,117.48) 171.66,117.33 171.66,116.89 UV1.AC29
GFX_FB-1: length 0.9
  BOTTOM w0.254: PC806.1 204.23,52.82 PR821.2
GFX_FB-2: length 2.2
  BOTTOM w0.102: PC817.1 200.48,51.05 v2(200.31,51.22)
  BOTTOM w0.254: PR818.2 202.44,51.05 PC817.1
GPIO21_BBEN: length 1.7
  TOP w0.102: v1(183.24,111.45) 182.94,111.45 T78.1
  BOTTOM w0.102: v1(183.24,111.45) 183.42,111.45 UV1.AJ14
GPIO24_TRSTB: length 2.9
  TOP w0.102: RP47.8 175.62,108.42 v1(176.08,108.88)
  BOTTOM w0.102: v1(176.08,108.88) 176.66,109.46 UV1.AM23
GPIO25_TDI: length 5.7
  TOP w0.102: v1(176.04,108.26) 176.12,108.18 RP47.7 176.12,106.69 175.9,106.48 175.4,106.48 175,106.08 175,104.79 v4(175.43,104.35)
  BOTTOM w0.102: UV1.AN23 176.47,108.69 v1(176.04,108.26)
GPIO26_TCK: length 5.1
  TOP w0.102: RP47.5 177.12,107.6 176.76,107.96 176.76,110.32 v4(176.49,110.58) v1(176.04,111.03)
  BOTTOM w0.102: UV1.AK23 176.1,111.09 v1(176.04,111.03)
GPIO27_TMS: length 6.6
  TOP w0.102: v4(174.04,111.45) 174.7,111.45 v1(176.05,110.1) 176.56,109.6 176.56,107.77 176.62,107.71 RP47.6
  BOTTOM w0.102: v1(176.05,110.1) 175.65,110.1 UV1.AL24
GPIO28_TDO: length 2
  TOP w0.102: T79.1 175.67,109.46 v1(176.08,109.46)
  BOTTOM w0.102: v1(176.08,109.46) 176.05,109.49 UV1.AM24
GPU_B+: length 13.5
  TOP w0.508: PR823.2 199.99,58.68 199.1,59.57 199.1,60.58 202.03,63.51 207.42,63.51 208.56,64.65
  vias: v2(210.87,77.67)
GPU_GPIO0: length 17.5
  IN3 w0.102: v1(179.7,112.14) 179.74,112.14 180.11,111.76 180.11,110.26 179.94,110.09 179.94,105.02 180.46,104.49
  IN3 w0.127: v1(181.57,98.24) 181.57,100.61 180.81,101.37 180.81,104.14 180.46,104.49
  BOTTOM w0.102: v1(181.57,98.24) 181.7,98.11 RV75.2 181.12,97.55 v2(180.62,98.05) ; v1(179.7,112.14) 179.46,112.37 UV1.AH20
GPU_GPIO1: length 17.3
  TOP w0.102: v1(182.59,98.19) v2(182.59,97.6)
  IN3 w0.102: 181.19,103.69 181.19,104.47 180.18,105.48 180.18,109.8 180.43,110.06 180.43,111.83 v1(180.96,112.36)
  IN3 w0.127: 181.19,103.69 181.19,101.67 182.15,100.72 182.15,98.63 v1(182.59,98.19)
  BOTTOM w0.102: v1(182.59,98.19) RV76.2 ; UV1.AH18 180.63,112.69 v1(180.96,112.36)
GPU_GPIO2: length 3.2
  TOP w0.102: RP60.8 184,108.29 v2(183.59,108.7) 183.24,109.05 v1(183.24,109.17)
  BOTTOM w0.102: v1(183.24,109.17) 182.76,108.69 UV1.AN16
GPU_GPIO6: length 108.9
  IN1 w0.102: 164.11,121.3 166.61,121.3 167.67,120.24 167.67,119.39 168.59,118.46 168.59,117.45 169.44,116.6 169.44,116.08 169.26,115.89 169.26,113.99 169.83,113.42 171.27,113.42 173.62,111.07 175.1,111.07 175.54,110.63 177.7,110.63 178.52,111.45 v1(180.87,111.45)
  IN1 w0.127: 164.11,121.3 162.33,121.3 158.64,124.98 156.26,124.98 155.73,125.51 155.73,127.02 157.17,128.45 157.17,133.07 160.54,136.44 160.54,152.49 v1(158.91,154.12)
  IN2 w0.127: v1(170.03,183.29) 171.35,181.97 171.35,162.25 168.56,159.46 162.51,159.46 158.91,155.85 v1(158.91,154.12)
  BOTTOM w0.102: v2(171.95,182.19) 172.55,182.79 PR1212.1 ; UV1.AJ17 181.32,111.89 v1(180.87,111.45)
  BOTTOM w0.254: PR1212.1 172.53,183.26 PR1214.1 PR1213.2 170.06,183.26 v1(170.03,183.29)
GPU_GPIO8: length 5.2
  TOP w0.102: v1(184.57,111.32) 184.99,110.89 v2(184.99,108.72) 184.99,107.36 185,107.35 RP60.6
  BOTTOM w0.102: UV1.AJ13 185.06,111.81 v1(184.57,111.32)
GPU_GPIO9: length 7.4
  TOP w0.102: v1(183.29,112.08) v2(184.11,112.08) 184.72,112.08 185.28,111.52 185.28,109.74 185.5,109.52 RP60.5
  BOTTOM w0.102: v1(183.29,112.08) 183.29,112.52 UV1.AH15
GPU_GPIO11: length 15.9
  TOP w0.102: v1(183.48,98.19) 183.48,98.03 v2(184.05,97.46)
  IN3 w0.102: v1(182.15,110.69) 182.14,110.69 181.49,110.04 181.49,106.97 182.14,106.31 182.14,104.91 182.59,104.46 182.59,103.69
  IN3 w0.127: v1(183.48,98.19) 182.59,99.08 182.59,103.69
  BOTTOM w0.102: v1(183.48,98.19) RV81.2 ; UV1.AK16 182.55,111.09 v1(182.15,110.69)
GPU_GPIO12: length 15
  IN3 w0.102: v1(182.14,109.86) 181.69,109.4 181.69,107.05 183.16,105.58 183.16,104.59 182.91,104.33 182.91,103.69
  IN3 w0.127: v1(184.37,98.19) 183.67,98.89 183.67,100.77 182.91,101.53 182.91,103.69
  BOTTOM w0.102: v2(183.96,98.49) 184.27,98.19 v1(184.37,98.19) RV82.2 ; v1(182.14,109.86) 182.58,110.29 UV1.AL16
GPU_GPIO13: length 14.5
  IN3 w0.102: 184.56,103.69 184.56,104.67 182.48,106.75 182.48,108.7 v1(182.15,109.03)
  IN3 w0.127: 184.56,103.69 184.56,99.6 185.26,98.9 v1(185.26,98.2)
  BOTTOM w0.102: v1(182.15,109.03) 182.61,109.49 UV1.AM16 ; v2(186.3,97.55) RV83.2 v1(185.26,98.2)
GPU_RST#: length 15.7
  TOP w0.102: v4(161.52,113.57) 161.82,113.27 v1(162.35,113.27)
  IN3 w0.102: v1(170.66,117.53) 170.16,117.03 168.08,117.03 167.27,116.22 166.63,116.22 165.68,115.27 164.11,115.27
  IN3 w0.127: v1(162.35,113.27) 162.35,113.67 163.94,115.27 164.11,115.27
  BOTTOM w0.102: UV13.4 161.27,110.39 161.72,110.83 RV66.1 161.72,112.65 v1(162.35,113.27) ; UV1.AA30 170.86,117.74 v1(170.66,117.53)
GPU_THERMAL_D+: length 29.5
  TOP w0.102: v1(171.17,113.89) v4(171.17,114.46)
  IN3 w0.102: v1(171.17,113.89) 171.17,113.76 172.89,112.04 172.89,111.14 173.23,110.81 173.23,107.22 174.16,106.29 175.02,106.29 176.07,105.23 176.07,104.71 175.87,104.5 175.87,103.69
  IN3 w0.127: 175.87,103.69 175.87,102.49 175.52,102.14 175.52,98.05 177.76,95.81 177.76,95.39 179.16,93.99 v1(179.16,92.97)
  BOTTOM w0.102: UV14.2 177.9,92.78 CV89.1 178.84,92.65 v1(179.16,92.97)
  BOTTOM w0.254: v1(171.17,113.89) 171.17,113.93 171.66,114.43 UV1.AF29
GPU_THERMAL_D-: length 25.6
  TOP w0.102: v1(177.25,95.69) v4(177.25,96.26)
  IN3 w0.102: v1(171.25,112.9) 172.69,111.46 172.69,111.06 173.03,110.72 173.03,107.13 174.07,106.09 174.93,106.09 175.82,105.2 175.82,104.77 175.62,104.56 175.62,103.69
  IN3 w0.127: 175.62,103.69 175.62,102.6 174.46,101.44 174.46,98.48 v1(177.25,95.69)
  BOTTOM w0.102: CV89.2 177.25,92.78 UV14.3 v1(177.25,95.69)
  BOTTOM w0.254: UV1.AG29 171.62,113.29 171.25,112.92 v1(171.25,112.9)
GPU_VGA_B: length 3.8
  BOTTOM w0.102: UV1.AF37 165.75,114.49 165.07,113.8 164.44,113.8 T87.1
GPU_VGA_DDCCLK: length 3.4
  TOP w0.102: v1(172.5,109.87) 172.5,108.99 T90.1
  BOTTOM w0.102: UV1.AK30 170.95,111.09 171.31,110.73 171.31,110.16 171.61,109.87 v1(172.5,109.87)
GPU_VGA_DDCDAT: length 1.5
  TOP w0.102: T91.1 172.7,110.63 v1(172.43,110.63)
  BOTTOM w0.102: v1(172.43,110.63) 171.97,111.09 UV1.AK29
GPU_VGA_G: length 3.9
  BOTTOM w0.102: UV1.AE36 166.24,115.29 165.86,114.91 165.41,114.91 165,115.33 164.29,115.33 163.56,114.6 T86.1
GPU_VGA_HSYNC: length 5.4
  BOTTOM w0.102: UV1.AC36 166.12,116.89 165.75,116.52 164.57,116.52 162.94,114.88 T88.1
GPU_VGA_R: length 4.8
  BOTTOM w0.102: UV1.AD39 164.56,116.09 162.03,113.56 T85.1
GPU_VGA_VSYNC: length 2.3
  BOTTOM w0.102: UV1.AC38 165.51,116.89 165.37,116.75 164.28,116.75 T89.1
GPU_VID1: length 83.5
  TOP w0.102: v2(209.75,60.87) 209.58,60.7 v1(209.58,60.27)
  TOP w0.254: v1(209.58,60.27) 209.64,60.21 PR828.2 209.63,59 PR810.1 PR819.2
  IN3 w0.102: 186.46,103.69 186.46,103.76 185.83,104.4 185.83,106.68 185.43,107.07 185.43,108.98 v1(184.49,109.92)
  IN3 w0.127: v1(209.58,60.27) 210.4,59.45 211.04,59.45 211.23,59.26 211.23,57.76 208.31,54.84 199.75,54.84 198.78,55.8 198.78,57.79 191.33,65.25 191.33,79.05 187.35,83.02 187.35,93.4 188.28,94.33 188.28,99.53 187.86,99.95 186.97,99.95 186.46,100.46 186.46,103.69
  BOTTOM w0.102: UV1.AL13 184.86,110.29 v1(184.49,109.92)
GPU_VID2: length 83.2
  IN3 w0.102: v1(184.47,110.57) 185.64,109.4 185.64,107.15 186.08,106.71 186.08,104.46 186.72,103.83 186.72,103.69
  IN3 w0.127: 186.72,103.69 186.72,100.59 187.1,100.21 188.01,100.21 188.53,99.69 188.53,94.22 187.6,93.29 187.6,83.13 191.58,79.15 191.58,65.36 199.04,57.9 199.04,55.91 199.86,55.09 208.2,55.09 210.13,57.02 210.13,58.4 v1(210.72,59)
  BOTTOM w0.102: v2(214.92,60.23) 213.58,60.23 213,59.65 PR826.2 ; UV1.AK14 183.95,111.09 v1(184.47,110.57)
  BOTTOM w0.254: PR812.1 210.27,59.22 210.27,59.22 210.42,59.07 210.42,59.07 210.48,59 v1(210.72,59) 211.61,59 212.13,59.52 PR834.2 212.2,59.51 PR826.2
GPU_VID3: length 82.7
  TOP w0.102: v1(212.69,58.75) v2(212.69,59.5)
  IN3 w0.102: v1(184.49,109.16) 185.13,108.52 185.13,106.62 185.57,106.18 185.57,104.3 186.18,103.69
  IN3 w0.127: 186.18,103.69 186.18,100.13 188.03,98.29 188.03,94.43 187.09,93.5 187.09,82.92 191.07,78.94 191.07,65.15 198.53,57.69 198.53,55.7 199.83,54.39 201.74,54.39 202.28,53.86 207.69,53.86 212.58,58.75 v1(212.69,58.75)
  BOTTOM w0.102: v1(184.49,109.16) 184.82,109.49 UV1.AM13
  BOTTOM w0.254: PR807.1 210.26,58.68 210.42,58.52 211.6,58.52 PR836.2 PR835.2 213,58.19 212.69,58.5 v1(212.69,58.75)
GPU_VID4: length 83.1
  TOP w0.102: v2(183.62,110.37) 183.24,109.99 v1(183.24,109.94)
  IN3 w0.102: 185.1,104.59 185.1,105.21 183.77,106.54 183.77,109.4 v1(183.24,109.94)
  IN3 w0.127: 185.1,104.59 185.1,104.06 185.68,103.49 185.68,99.92 185.95,99.64 185.95,97.09 186.84,96.21 186.84,82.81 190.82,78.84 190.82,65.04 198.28,57.58 198.28,55.59 199.73,54.14 201.64,54.14 202.17,53.6 207.79,53.6 210.46,56.27 v1(212.18,56.27)
  BOTTOM w0.102: v1(183.24,109.94) 183.69,109.49 UV1.AM14
  BOTTOM w0.254: v1(212.18,56.27) 212.44,56.27 213,56.83 PR837.2 PR838.2 211.6,56.56 210.86,56.56 210.42,57 210.42,57.29 210.27,57.44 210.27,57.44 PR809.1
GPU_VID5: length 84.3
  IN3 w0.127: v1(212.18,54.94) 211.93,55.19 209.74,55.19 207.9,53.35 202.07,53.35 201.53,53.88 199.62,53.88 198.02,55.49 198.02,57.48 190.56,64.94 190.56,78.73 186.59,82.71 186.59,96.11 185.7,96.99 185.7,98.82 184.81,99.71 184.81,104.85 183.4,106.26 183.4,108.16 182.64,108.92 182.64,110.95 v1(182.14,111.45)
  BOTTOM w0.102: v1(182.14,111.45) 182.59,111.89 UV1.AJ16 ; v1(212.18,54.94) v2(212.18,54.12)
  BOTTOM w0.254: PR806.1 209.98,56.91 210.7,56.18 211.52,56.18 PR840.2 ; v1(212.18,54.94) 212.13,54.99 PR840.2 ; PR840.2 PR839.2
GREEN_CRT: length 7.8
  BOTTOM w0.102: U4.9 16.7,103.59 16.45,103.85 15.88,103.85 15.78,103.95 14,103.95 13.57,104.38 v2(13.36,104.38) R33.1 C3.1 11.33,103.88 11.36,103.86 L8.1
GREEN_CRT_L: length 8.3
  TOP w0.102: JCRT1.2 6.53,104.58 v2(7.33,104.58) 8.43,105.68 DE4.3 9.49,104.9 v1(9.3,104.71)
  BOTTOM w0.102: v1(9.3,104.71) 9.73,104.71 C6.1 10.16,104.28 L8.2
H_CATERR#: length 6
  TOP w0.089: v1(89.58,120.24) 90.08,119.74 RC58.2 90.82,119.58 v2(91.06,119.82)
  BOTTOM w0.076: v1(89.58,120.24) 89.71,120.11 89.73,120.11 89.96,119.88 90.69,119.88 90.73,119.84 91.16,119.84 91.42,119.59 91.77,119.59 91.94,119.76 91.94,119.93 92.18,120.17 92.7,120.17 UC1.K61
H_CPU_SVIDALRT#: length 8.8
  BOTTOM w0.076: v2(87.25,118.69) 87.85,118.69 88.5,119.34 90.96,119.34 91.46,118.84 91.77,118.84 92.06,119.13 UC1.L62
  BOTTOM w0.089: 86.76,118.69 v2(87.25,118.69)
  BOTTOM w0.102: R254.1 86.76,118.69
H_CPU_SVIDCLK: length 10.6
  BOTTOM w0.089: 86.76,117.35 87.27,117.35 88.41,118.49 91.54,118.49 UC1.N63
  BOTTOM w0.102: 86.76,117.35 v2(86.01,117.35) 83.66,117.35 C5212.1 R248.2
H_CPU_SVIDDATA: length 12.5
  BOTTOM w0.076: UC1.L63 91.41,119.13 91.03,119.51 88.1,119.51
  BOTTOM w0.089: 86.76,119.25 87.84,119.25 88.1,119.51
  BOTTOM w0.102: 86.76,119.25 v2(85.42,119.25) 81.89,119.25 81.56,119.58 R256.2 79.92,120.5 R257.1
H_CPUPWRGD: length 80.1
  TOP w0.102: v1(60.83,86.75) v4(60.83,86.03)
  IN3 w0.127: v1(60.83,86.75) 59.56,88.02 59.56,92.88 56.73,95.7 56.73,107.72 69.52,120.5 79.84,120.5 84.56,125.22 v1(85.78,125.22)
  BOTTOM w0.076: 91.09,126.96 91.99,126.06 92.95,126.06 93.22,125.79 93.22,125.42 93.29,125.35 93.29,124.76 93.28,124.75 UC1.C61
  BOTTOM w0.102: 91.09,126.96 90.71,127.33 90.13,127.33 89.25,128.22 RC66.1 CC27.1 86.85,126.28 v1(85.78,125.22) ; v1(60.83,86.75) 60.83,86.75 64.71,86.75 66.14,88.18 66.14,89.17 65.44,89.86 RC48.1
H_PROCHOT#: length 313.7
  TOP w0.089: 87.93,120.57 87.79,120.43 86.91,120.43 86.76,120.28 ; RC67.1 88.37,120.93
  TOP w0.102: PQ3.6 131.3,163.6 131.47,163.78 131.47,165.24 v1(131.41,165.3) ; 87.93,120.57 RC60.2 88.32,120.93 88.37,120.93 ; 86.76,120.28 86.69,120.22 v1(86.26,120.22) ; PQ2.6 129.94,168.81 129.82,168.92 129.82,169.3 129.95,169.43 v1(130.27,169.43) ; v1(179.52,50.35) v4(179.95,50.78) 180.5,51.33 RE44.2 180.48,53.48 179.67,53.48 179.43,53.72 UE2.4 179.43,55.26 CE19.1 ; PQ3.3 129.65,162.3 129.76,162.19 v1(129.76,161.81)
  IN1 w0.114: v1(130.27,169.43) 130.27,167.14 131.41,166 v1(131.41,165.3) 131.41,163.46 v1(129.76,161.81)
  IN1 w0.127: v1(129.76,161.81) 129.76,161.08 130.33,160.51 130.33,140.73 128.24,138.64 119.19,138.64 117.87,137.32 114.52,137.32 112.53,135.33 109.4,135.33 108.76,134.69 96.49,134.69 95.77,133.97 v1(89.12,133.97)
  IN3 w0.127: v1(179.52,50.35) 178.71,49.54 176.24,49.54 175.62,48.92 141,48.92 140.54,48.46 115.98,48.46 114.9,49.54 69.93,49.54 64.4,55.07 64.4,70.95 61.35,74 61.35,87.69 60.07,88.97 60.07,96.31 61.45,97.69 61.45,100.83 60.79,101.5 60.79,109.58 68.94,117.73 78.2,117.73 78.94,116.99 83.31,116.99 86.26,119.95 v1(86.26,120.22) 86.26,120.24 86.02,120.48 86.02,121.91 86.38,122.27 87.38,122.27 87.5,122.39 88.93,122.39 89.37,122.83 89.37,127.65 87.72,129.3 87.72,131.14 89.12,132.53 v1(89.12,133.97)
H_PROCHOT#_R: length 2.4
  TOP w0.089: v1(90.2,120.27) 90.48,120.55 RC67.2
  BOTTOM w0.076: UC1.K63 91.52,120 90.79,120 90.53,120.27 v1(90.2,120.27)
H_THERMTRIP#: length 16.2
  BOTTOM w0.076: UC1.D60 93.43,123.76 92.97,124.22 92.97,124.43 92.63,124.77 92.63,124.97 92.44,125.17 92.01,125.17 91.62,125.56 90.69,125.56 90.11,126.15 89.69,126.15
  BOTTOM w0.102: 89.69,126.15 89.54,126.31 87.77,126.31 86.25,124.79 84.52,124.79 83.15,123.42 v2(81.51,123.42) R2346.2
H_VCCST_PWRGD_XDP: length 4.8
  BOTTOM w0.102: v2(66.56,90.42) 65.95,91.03 RC48.2 65.17,91.03 64.47,91.74 64.2,91.74 63.7,92.23 JXDP1.39
H_VR_READY: length 19
  TOP w0.254: PR540.2 85.47,136.55 v1(85.45,136.57)
  IN3 w0.127: v1(82.39,134.44) 83.34,135.39 84.93,135.39 85.45,135.91 v1(85.45,136.57)
  BOTTOM w0.102: R251.1 90.52,129.77 90.09,130.19 87.49,130.19 87.08,130.6 86.59,130.6 85.63,131.57 v2(85.63,132.43) 85.63,132.81 84.88,133.56 83.61,133.56 82.74,134.44 v1(82.39,134.44)
  BOTTOM w0.203: PU501.3 86.14,136.82 85.68,137.28 PR524.2
  BOTTOM w0.254: PR524.2 85.46,136.59 v1(85.45,136.57)
HDA_SPKR: length 181.9
  TOP w0.102: DA8.3 v2(37.16,35.17) 37.16,50 34.41,52.76 v1(34.41,71.28)
  IN2 w0.089: 121.75,93.61 124.22,96.09 125.57,96.09 126.9,97.42 129.93,97.42 130.51,98 130.51,98.49 131.03,99.01 131.03,102.88 130.27,103.64 130.27,110.95 131.79,112.47 132.36,112.47 132.85,112.96 132.85,113.49 133.8,114.44 135.6,114.44 v1(136.14,114.97)
  IN2 w0.127: 121.75,93.61 112.92,84.78 59.36,84.78 45.39,70.81 34.87,70.81 v1(34.41,71.28)
  BOTTOM w0.076: UC1.V2 129.86,115.34 130.16,115.64 131.28,115.64 131.41,115.77 135.34,115.77 v1(136.14,114.97)
  BOTTOM w0.089: RC121.2 135.59,114.43 v1(136.14,114.97)
HDD_DET#: length 187.9
  TOP w0.089: v1(135.6,113.55) 135.6,113.55 135.6,113.55 v2(135.6,114.16) 135.6,114.95 135.08,115.47 RC9.1
  IN2 w0.127: v1(141.93,45.29) 142.46,45.82 142.46,73.23 140.43,75.26 140.43,97.42 136.74,101.1 136.74,110.12 135.47,111.39 135.47,113.43 v1(135.6,113.55)
  IN3 w0.084: v1(135.6,113.55) 135.38,113.33 133.27,113.33 132.54,114.06 130.52,114.06 129.19,112.72 128.62,112.72 128.25,112.36 128.25,111.79 128.05,111.58 127.66,111.58 v1(127.22,111.14)
  IN3 w0.127: v1(141.93,45.29) 171.02,45.29 171.72,45.98 178.4,45.98 179.41,44.98 180.81,44.98 181.57,44.22 184.29,44.22 185.05,44.98 188.81,44.98 189.27,45.43 193.17,45.43 197.11,41.49 197.11,38.32 197.96,37.48 199.55,37.48 200.79,38.72 211.72,38.72 212.4,39.41 215.99,39.41 226.41,49.83 226.41,55.64 JHDD.12
  BOTTOM w0.089: UC1.AG6 126.99,110.91 v1(127.22,111.14)
HOST_ALERT1_R_N: length 22.8
  TOP w0.102: v2(145.03,113.34) 144.59,112.89 v1(144.59,112.88)
  IN1 w0.084: 137.68,111.26 137.15,111.26 136.23,110.35 134.74,110.35 134.51,110.12 130.74,110.12 130,110.87 130,112.04 129.57,112.47 127.03,112.47 v1(126.65,112.09)
  IN1 w0.127: 137.68,111.26 141.98,111.26 143.65,112.94 144.53,112.94 v1(144.59,112.88)
  BOTTOM w0.089: v1(126.65,112.09) 126.34,112.4 UC1.AD7
  BOTTOM w0.102: v1(144.59,112.88) 144.67,112.8 RC120.2
HPOUT-L: length 15.8
  TOP w0.203: v1(22.44,20.07) 22.71,20.33 23.14,20.33 23.21,20.26 23.24,20.26 23.45,20.05 UA1.32
  IN1 w0.254: v1(22.44,20.07) 22.44,20.08 22.19,20.33 20.65,20.33 19.52,19.21 19.52,15.89 21.77,13.65 v1(23.13,13.65)
  BOTTOM w0.254: v1(23.13,13.65) v2(23.13,12.57) 23.13,12.25 23.78,11.61 RA55.1
HPOUT-R: length 13.8
  TOP w0.203: UA1.33 23.09,19.65 23.02,19.72 23.02,19.85 v1(23,19.85)
  IN1 w0.254: v1(23,19.85) 22.73,19.58 22.68,19.58 22.66,19.56 22.23,19.56 21.97,19.82 20.86,19.82 20.03,19 20.03,16.1 21.95,14.18 23.33,14.18 v1(23.84,13.68)
  BOTTOM w0.254: RA56.1 24.04,13.47 v1(23.84,13.68)
HSYNC_BUF: length 12.2
  TOP w0.102: v1(15.59,109.8) R13.1
  IN3 w0.127: v1(15.59,109.8) 15.59,101.34 16.22,100.71 v1(16.54,100.71)
  BOTTOM w0.102: v1(16.54,100.71) 16.63,100.8 U4.2 ; v2(15.59,109.22) v1(15.59,109.8)
HSYNC_BUF_L: length 2.3
  TOP w0.102: U1.4 14.08,108.85 14.7,109.47 R3.1
I2C0_SCL: length 7.9
  BOTTOM w0.089: UC1.F3 129.37,122.44 129.88,122.44 130.07,122.63 130.4,122.63 130.6,122.82 133.25,122.82 135.2,124.78 RP53.4
I2C0_SDA: length 7
  BOTTOM w0.076: UC1.F2 129.77,122.09 130.14,122.46 130.54,122.46 130.73,122.65 132.41,122.65
  BOTTOM w0.089: 132.41,122.65 133.32,122.65 134.95,124.28 RP53.3
I2C1_SCL_TCH_PAD: length 6.1
  BOTTOM w0.089: UC1.F1 130.38,122.22 130.74,122.22 130.98,122.47 133.51,122.47 v3(134.37,123.33) 134.68,123.63 135.13,123.63 135.27,123.78 RP53.2
I2C1_SDA_TCH_PAD: length 8.3
  BOTTOM w0.089: RP53.1 135.27,123.28 135.13,123.42 134.76,123.42 134.52,123.17 133.6,122.25 131.07,122.25 130.83,122.01 130.64,122.01 130.38,121.75 128.7,121.75 UC1.G4
ILMT_1.05V: length 4.2
  BOTTOM w0.254: PR306.1 PR304.2 147.77,152.78 146.95,153.6 146.95,153.7 v2(146.64,154.02) 146.13,154.53 PU300.3
ILMT_VDDCI: length 4.7
  BOTTOM w0.254: PU1200.3 179.39,184.43 180.23,185.27 v2(180.65,185.27) 180.9,185.27 181.32,185.68 PR1203.2 PR1202.1
IMON_CPU: length 4.5
  BOTTOM w0.102: PR501.2 88.33,142.42 v2(88.33,143.11)
  BOTTOM w0.203: PC508.2 89.42,141.02 PU501.13
  BOTTOM w0.254: PR501.2 88.83,142.14 89.67,141.3 PC508.2
IMVP_PWRGD: length 237
  TOP w0.102: UE1.85 v1(187.59,50.05)
  TOP w0.254: v1(54.51,95.45) 54.51,100.47 v2(55.2,101.15) 55.72,101.67 55.72,104.71 74.25,123.24 82.99,123.24 84.24,124.48 85.78,124.48 86.4,125.1 86.4,131.16 86.21,131.35 86.21,131.57 83.38,134.4 83.38,135.29 PC523.1 83.51,135.39 PR540.1
  IN3 w0.127: v1(54.51,95.45) 58.26,91.7 58.26,58.05 68.91,47.4 114.88,47.4 115.35,46.94 141.36,46.94 141.49,47.06 168.5,47.06 168.72,47.28 177.72,47.28 178.91,48.47 184.89,48.47 186.47,50.05 v1(187.59,50.05)
INT-SPK-L+: length 38.8
  TOP w0.203: UA1.42 26.88,17.09 27.02,16.95 27.02,16.33 26.89,16.2
  TOP w0.508: 62.83,24.65 LA6.1
  IN1 w0.762: 27.52,16.96 28.35,17.79 30.26,17.79 31.02,17.03 40.54,17.03 42.38,18.87 48.73,18.87 54.51,24.65 60.54,24.65
  vias: v1(26.31,15.35) v1(26.72,15.77) v1(61.75,24.84) v1(62.39,24.84)
INT-SPK-L-: length 37.2
  TOP w0.203: UA1.43 27.28,17.16 27.35,17.09 27.35,15.96 27.31,15.92
  TOP w0.508: 62.77,24.01 LA5.1
  IN1 w0.762: 29.18,16.65 29.78,16.65 30.54,15.89 41.02,15.89 42.86,17.73 49.21,17.73 54.99,23.51 60.67,23.51
  vias: v1(26.79,14.96) v1(27.21,15.38) v1(61.69,23.63) v1(62.32,23.63)
INT-SPK-R+: length 37
  TOP w0.203: 28.32,15.44 28.01,15.75 28.01,16.81 28.08,16.88 UA1.45
  TOP w0.508: 63.75,21.63 LA4.1
  IN1 w0.762: 30.09,14.59 41.34,14.59 43.33,16.58 49.68,16.58 54.95,21.85 60.29,21.85
  IN1 w1.016: 30,14.68 30.09,14.59
  BOTTOM w0.102: v1(29.05,14.87) v2(29.93,14.87)
  vias: v1(28.48,15) v1(62.58,21.98) v1(63.21,21.98)
INT-SPK-R-: length 39.1
  TOP w0.203: v1(27.83,15) 27.68,15.15 UA1.44
  TOP w0.508: 63.75,21 LA3.1
  IN1 w0.762: 60.23,20.71 55.42,20.71 50.15,15.44 43.8,15.44 41.81,13.45 28.63,13.45 28.48,13.6
  BOTTOM w0.102: v1(27.83,14.36) 27.83,14.17 v2(28.5,13.5)
  vias: v1(62.51,20.65) v1(63.15,20.65)
INTRUDER#: length 11.7
  BOTTOM w0.076: UC1.AU6 127.23,104.59 127.23,104.09 127.19,104.05 127.19,102.72
  BOTTOM w0.089: 127.19,102.72 127.47,102.45 127.47,102.22 127.47,102.07 128.13,101.41 128.31,101.41 129.04,100.68 129.72,100.68 130.44,99.97 v2(131.01,99.97) 131.36,99.97 131.57,100.18
  BOTTOM w0.102: 131.57,100.18 134.38,100.18 RC7.2
ISOLATEB: length 3.3
  TOP w0.102: v1(41.43,84.64) 41.62,84.83 RL35.2 RL33.2
  BOTTOM w0.102: v1(41.43,84.64) 41.26,84.47 v2(40.93,84.47) UL1.20
ISPSCL_R: length 19.6
  IN3 w0.127: v1(19.51,108.13) 19.69,108.3 19.69,108.54 19.52,108.71 18.07,108.71 17.87,108.51 17.87,107.94 18.19,107.62 18.19,100.46 16.95,99.21 15.49,99.21 14.86,98.58 13.83,98.58 v1(13.68,98.42)
  BOTTOM w0.102: v1(13.68,98.42) 13.87,98.61 14.11,98.61 R20.1 ; R42.1 19.51,108.46 v1(19.51,108.13) 20.05,107.59 U4.19
ISPSDA_R: length 20
  IN3 w0.127: v1(20.09,108.13) 19.92,108.3 19.92,108.64 19.62,108.94 17.97,108.94 17.64,108.61 17.64,107.84 17.96,107.53 17.96,100.55 16.85,99.44 15.4,99.44 14.76,98.8 13.88,98.8 v1(13.68,99.01)
  BOTTOM w0.102: R21.1 19.9,108.57 19.9,108.32 v1(20.09,108.13) 20.09,107.83 20.26,107.66 20.26,107.17 20.45,106.99 U4.20 ; R37.1 14.06,98.82 13.87,98.82 v1(13.68,99.01)
ISUM+: length 8.2
  BOTTOM w0.203: 201.76,57.03 202.19,57.03 202.26,56.96 202.27,56.96 202.34,56.88 202.72,56.88 202.85,57.01 PU800.10
  BOTTOM w0.254: PR827.1 PR816.1 ; PR827.1 199.13,57.47 v2(200.02,57.47) 201.32,57.47 201.76,57.03 ; PR827.1 PC820.1 PC819.1 199.1,59.27 PR829.2
ISUM-: length 4.2
  BOTTOM w0.102: v2(200.84,56.46) 200.84,56.21 201.54,55.51 PR825.1
  BOTTOM w0.203: 202.02,56.65 202.12,56.55 202.86,56.55 202.92,56.61 PU800.9
  BOTTOM w0.254: PR825.1 201.59,56.4 201.84,56.65 202.02,56.65
ISUM-1: length 32.2
  TOP w0.254: v1(197.58,60.27) v2(197.58,59.27) 197.58,57.99 v1(200.05,55.51) 200.05,55.06 200.5,54.62 PC821.2
  BOTTOM w0.254: PH800.2 203.57,78.46 203.34,78.46 201.77,76.89 201.77,75.77 200.44,74.43 200.44,64.46 197.58,61.61 v1(197.58,60.27) 197.72,60.13 PR830.2 198.21,59.27 PC819.2 PC820.2 PR827.2 ; PR825.2 v1(200.05,55.51)
ISUM-2: length 26.1
  BOTTOM w0.254: PR816.2 198.09,56.59 197.64,57.03 197.64,59.38 197.07,59.95 197.07,60.59 197.2,60.72 197.2,61.76 200.05,64.62 200.05,74.69 v2(201.33,75.96) 201.33,76.99 203.18,78.84 203.62,78.84 PH800.1
JACK_PLUG#: length 28.9
  TOP w0.102: RA1.2 30.1,27.37 29.41,28.06 v2(29.35,28.06)
  TOP w0.254: v1(30.13,24.71) 30.57,25.16 RA4.1 30.69,25.59 31.14,26.05 31.14,27.19 30.97,27.37 RA1.2
  IN1 w0.254: v1(30.13,24.71) 28.78,23.37 25.11,23.37 23.28,21.54 22.06,21.54 21.39,22.21 20.91,22.21 20.56,21.85 19.46,21.85 19.14,21.54 15.69,21.54 JHP.5
  BOTTOM w0.254: RA3.1 28.97,23.56 v1(30.13,24.71)
JACK_SENSE#: length 14
  TOP w0.254: v1(29.01,25.08) 29.01,26.2 29.32,26.5 RA51.2 RA4.2
  IN3 w0.254: v1(29.01,25.08) 29.24,25.31 29.24,26.37 28.49,27.12 25.49,27.12 23.92,25.55 v1(23.92,25.13)
  BOTTOM w0.254: v1(23.92,25.13) 24.37,24.68 v2(24.98,24.68) 25.58,24.68 25.85,24.95 QA5.3
JHDD_P10: length 15.3
  TOP w0.102: JHDD.10 219.06,53.9 216.79,56.17 RS7.2 RS8.2 216.79,59.12 v2(216.08,59.83)
KB_CAPS_PWR: length 3.1
  TOP w0.102: v1(227.55,157.42) JKB.4
  BOTTOM w0.102: v2(226.45,157.76) 226.8,157.42 v1(227.55,157.42) 227.66,157.31 RE60.2
KB_RST#: length 148.9
  TOP w0.102: UE1.2 183.59,37.07 v1(183.71,37.2)
  IN1 w0.127: v1(191.42,37.73) 191.42,37.75 194.11,40.44 194.11,50.31 194.31,50.51 194.31,53.81 194.05,54.07 194.05,54.24 192.88,55.41 192.88,56.44 191.39,57.93 191.39,64.96 190.31,66.04 190.31,76.08 183.12,83.27 179.1,83.27 174.06,88.31 169.69,88.31 155.22,102.77 155.22,104.6 154.15,105.67 154.15,108.47 150.02,112.6 149.46,112.6 148.43,113.63 148.43,115.2 v1(147.67,115.96)
  IN3 w0.084: 137.82,113.6 136.87,114.55 132.05,114.55 131.2,115.39 128.35,115.39 v1(127.85,115.89)
  IN3 w0.127: v1(183.71,37.2) 183.71,36.84 184.22,36.33 190.3,36.33 190.97,37 190.97,37.28 v1(191.42,37.73) ; v1(147.67,115.96) 147.41,115.96 146.87,115.42 144.23,115.42 143.94,115.14 142.97,115.14 141.16,113.33 138.09,113.33 137.82,113.6
  BOTTOM w0.089: v1(127.85,115.89) 128.33,115.41 UC1.V4
  BOTTOM w0.102: RP43.8 141.57,122.31 141.22,121.96 141.22,120.63 141.22,120.62 141.22,120.59 142.36,119.45 142.9,119.45 143.29,119.07 144.61,119.07 146,117.69 v2(146,117.1) 146,116.22 146.45,115.77 147.48,115.77 v1(147.67,115.96)
KSI0: length 132.1
  TOP w0.102: v1(221.83,141.46) 221.89,141.51 223.56,141.51 225.07,143.02 JKB.22 ; UE1.55 198.4,46.11 v1(198.47,46.17)
  IN3 w0.127: v1(221.83,141.46) 221.31,140.93 221.31,139.13 221.63,138.81 221.63,137.02 220.78,136.16 220.78,135.42 219.77,134.42 219.77,121.73 219.65,121.61 219.65,105.32 215.99,101.66 215.99,100.83 214.79,99.62 214.79,91.99 215.88,90.89 217.38,90.89 220.1,88.17 220.1,85.61 218.76,84.27 218.76,78.56 221.23,76.1 221.23,61.57 220.59,60.93 220.59,51.41 216.3,47.13 199.4,47.13 198.47,46.19 v1(198.47,46.17)
  BOTTOM w0.102: v1(198.47,46.17) v2(197.5,46.17)
KSI1: length 130.3
  TOP w0.102: v1(199.05,46.17) 198.64,46.58 198.24,46.58 198.16,46.51 UE1.56 ; v1(221.9,140.28) 223.23,140.28 224.37,141.42 JKB.24
  IN3 w0.127: v1(199.05,46.17) 199.05,46.19 199.72,46.86 216.4,46.86 220.84,51.29 220.84,60.83 221.48,61.47 221.48,76.22 219.03,78.67 219.03,84.18 220.35,85.5 220.35,89.21 217.98,91.58 217.2,91.58 215.97,92.81 215.97,94.38 215.96,94.39 215.96,96.89 215.95,96.9 215.95,99.9 216.69,100.64 216.69,101.99 219.91,105.21 219.91,116.06 220.62,116.77 220.62,120.82 220.03,121.4 220.03,134.31 221.89,136.17 221.89,138.96 221.57,139.27 221.57,140.08 221.77,140.28 v1(221.9,140.28)
  BOTTOM w0.102: v1(199.05,46.17) v2(199.05,46.99)
KSI2: length 130.3
  TOP w0.102: JKB.26 227.47,139.82 227.07,139.43 222.02,139.43 v1(222,139.45) ; v1(199.64,46.17) 199,46.81 198.26,46.81 198.17,46.91 UE1.57
  IN3 w0.127: v1(222,139.45) 222.17,139.27 222.17,136.08 220.29,134.2 220.29,121.51 220.88,120.92 220.88,116.66 220.17,115.95 220.17,110.96 220.9,110.24 220.9,109.84 221.58,109.16 221.58,105.1 216.21,99.74 216.21,94.49 216.22,94.49 216.22,92.91 217.31,91.83 218.09,91.83 220.61,89.31 220.61,85.4 219.29,84.08 219.29,78.78 221.73,76.33 221.73,61.36 221.09,60.72 221.09,51.18 216.51,46.6 200.04,46.6 199.64,46.19 v1(199.64,46.17)
  BOTTOM w0.102: v1(222,139.45) v2(222,138.79)
KSI3: length 134.9
  TOP w0.102: v4(201.04,45.41) 200.28,46.17 v1(200.22,46.17) 199.81,46.59 199.55,46.59 199.09,47.04 198.4,47.04 198.13,47.31 UE1.58 ; JKB.23 224.85,142.22 223.5,140.88 v1(221.9,140.88)
  IN3 w0.127: v1(221.9,140.88) 222.21,140.88 222.64,140.44 222.64,131.35 221.16,129.87 221.16,116.15 220.44,115.43 220.44,111.07 221.16,110.35 221.16,109.95 221.84,109.27 221.84,102.56 219.82,100.54 217.78,100.54 216.48,99.24 216.48,94.25 216.48,94.24 216.48,93.22 216.48,93.22 216.48,93.01 217.41,92.09 219.13,92.09 220.86,90.35 220.86,85.29 219.59,84.02 219.59,78.85 221.99,76.44 221.99,61.27 221.35,60.62 221.35,51.06 216.46,46.17 v1(200.22,46.17)
KSI4: length 129
  TOP w0.102: v4(200.09,46.89) 200.05,46.92 199.79,46.92 199.42,47.29 198.88,47.29 v1(198.47,47.71) UE1.59 ; JKB.27 222.73,139.02 222.07,138.36 v1(220.95,138.36)
  IN3 w0.127: v1(198.47,47.71) 198.47,47.77 199.54,48.84 209.66,48.84 210.33,48.17 215.87,48.17 219.57,51.88 219.57,61.36 220.21,62 220.21,75.64 217.72,78.13 217.72,84.34 217.72,84.35 217.72,84.74 219.08,86.09 219.08,87.75 216.96,89.88 215.46,89.88 213.74,91.6 213.74,100.89 218.61,105.76 218.61,122.04 218.72,122.16 218.72,136.14 v1(220.95,138.36)
KSI5: length 129.5
  TOP w0.102: v1(199.05,47.71) 199.05,48.21 v4(198.97,48.28) 198.48,48.28 198.3,48.11 UE1.60 ; v1(220.93,138.94) 220.93,139.25 221.56,139.87 226.17,139.87 226.91,140.62 JKB.25
  IN3 w0.127: v1(199.05,47.71) 199.05,47.77 199.86,48.58 209.57,48.58 210.23,47.91 215.98,47.91 219.82,51.76 219.82,61.25 220.46,61.89 220.46,75.75 217.98,78.24 217.98,84.63 219.34,85.99 219.34,87.85 217.06,90.13 215.57,90.13 214,91.69 214,100.78 218.87,105.65 218.87,121.94 218.99,122.05 218.99,136.03 220.89,137.94 221.12,137.94 221.37,138.18 221.37,138.53 220.96,138.94 v1(220.93,138.94)
KSI6: length 129.8
  TOP w0.102: UE1.61 198.07,48.51 198.23,48.66 199.17,48.66 199.64,48.2 v1(199.64,47.71) 200.06,47.28 201.7,47.28 v4(201.82,47.17) ; JKB.28 226.98,138.22 226.2,137.44 v1(221,137.44)
  IN3 w0.127: v1(221,137.44) 220.77,137.44 219.25,135.92 219.25,121.95 219.13,121.83 219.13,105.54 214.26,100.67 214.26,92.44 214.27,92.43 214.27,91.78 215.67,90.38 217.17,90.38 219.59,87.96 219.59,85.82 218.24,84.47 218.24,78.35 220.72,75.87 220.72,61.78 220.08,61.15 220.08,51.64 216.09,47.65 210.12,47.65 209.45,48.32 200.17,48.32 199.64,47.79 v1(199.64,47.71)
