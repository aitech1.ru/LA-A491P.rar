# Allegro board LAA491PR10-0624.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
HB_A090420-SAHR21_4P
  oval 0.61x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 2.489x2.21 smd: 5(-3,-3.15) 6(6,-3.15)
HB_A823020-SBHR21_30P
  oval 0.305x1.295 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0) 13(9.6,0) 14(10.4,0) 15(11.2,0) 16(12,0) 17(12.8,0) 18(13.6,0) 19(14.4,0) 20(15.2,0) 21(16,0) 22(16.8,0) 23(17.6,0) 24(18.4,0) 25(19.2,0) 26(20,0) 27(20.8,0) 28(21.6,0) 29(22.4,0) 30(23.2,0)
  rect 1.803x2.21 smd: 31(25.55,-5.65) 32(-2.35,-5.65)
IP4223CZ6_SO6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
IP4292CZ10-TBR_XSON10_2P5X1
  oval 0.254x0.889 smd: 1(0,0)
  oval 0.254x0.838 smd: 2(0.5,-0.025) 3(1,-0.025) 4(1.5,-0.025) 5(2,-0.025) 6(2,1.125) 7(1.5,1.125) 8(1,1.125) 9(0.5,1.125) 10(0,1.125)
ISL62881HRZ-T_QFN28_4X4
  oval 0.203x1.092 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 15(2.4,3.9) 16(2,3.9) 17(1.6,3.9) 18(1.2,3.9) 19(0.8,3.9) 20(0.4,3.9) 21(0,3.9)
  oval 1.092x0.203 smd: 8(3.15,0.75) 9(3.15,1.15) 10(3.15,1.55) 11(3.15,1.95) 12(3.15,2.35) 13(3.15,2.75) 14(3.15,3.15) 22(-0.75,3.15) 23(-0.75,2.75) 24(-0.75,2.35) 25(-0.75,1.95) 26(-0.75,1.55) 27(-0.75,1.15) 28(-0.75,0.75)
  rect 2.388x2.388 smd: 29(1.2,1.95)
IT6511FN_QFN56_7X7
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 29(5.2,6.95) 30(4.8,6.95) 31(4.4,6.95) 32(4,6.95) 33(3.6,6.95) 34(3.2,6.95) 35(2.8,6.95) 36(2.4,6.95) 37(2,6.95) 38(1.6,6.95) 39(1.2,6.95) 40(0.8,6.95) 41(0.4,6.95) 42(0,6.95)
  oval 1.041x0.203 smd: 15(6.075,0.875) 16(6.075,1.275) 17(6.075,1.675) 18(6.075,2.075) 19(6.075,2.475) 20(6.075,2.875) 21(6.075,3.275) 22(6.075,3.675) 23(6.075,4.075) 24(6.075,4.475) 25(6.075,4.875) 26(6.075,5.275) 27(6.075,5.675) 28(6.075,6.075) 43(-0.875,6.075) 44(-0.875,5.675) 45(-0.875,5.275) 46(-0.875,4.875) 47(-0.875,4.475) 48(-0.875,4.075) 49(-0.875,3.675) 50(-0.875,3.275) 51(-0.875,2.875) 52(-0.875,2.475) 53(-0.875,2.075) 54(-0.875,1.675) 55(-0.875,1.275) 56(-0.875,0.875)
  rect 4.699x3.912 smd: 57(2.6,3.475)
JESS_UCNR2210M008-0_8P
  oval 0.508x1.295 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0)
  rect 2.489x1.905 smd: 9(-9.65,3.3) 10(2.65,3.3)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4G20325FC-HC05_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
KB9012QF-A2_LQFP128_14X14
  oval 0.203x1.753 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 21(8,0) 22(8.4,0) 23(8.8,0) 24(9.2,0) 25(9.6,0) 26(10,0) 27(10.4,0) 28(10.8,0) 29(11.2,0) 30(11.6,0) 31(12,0) 32(12.4,0) 65(12.4,15.654) 66(12,15.654) 67(11.6,15.654) 68(11.2,15.654) 69(10.8,15.654) 70(10.4,15.654) 71(10,15.654) 72(9.6,15.654) 73(9.2,15.654) 74(8.8,15.654) 75(8.4,15.654) 76(8,15.654) 77(7.6,15.654) 78(7.2,15.654) 79(6.8,15.654) 80(6.4,15.654) 81(6,15.654) 82(5.6,15.654) 83(5.2,15.654) 84(4.8,15.654) 85(4.4,15.654) 86(4,15.654) 87(3.6,15.654) 88(3.2,15.654) 89(2.8,15.654) 90(2.4,15.654) 91(2,15.654) 92(1.6,15.654) 93(1.2,15.654) 94(0.8,15.654) 95(0.4,15.654) 96(0,15.654)
  oval 1.753x0.203 smd: 33(14.027,1.627) 34(14.027,2.027) 35(14.027,2.427) 36(14.027,2.827) 37(14.027,3.227) 38(14.027,3.627) 39(14.027,4.027) 40(14.027,4.427) 41(14.027,4.827) 42(14.027,5.227) 43(14.027,5.627) 44(14.027,6.027) 45(14.027,6.427) 46(14.027,6.827) 47(14.027,7.227) 48(14.027,7.627) 49(14.027,8.027) 50(14.027,8.427) 51(14.027,8.827) 52(14.027,9.227) 53(14.027,9.627) 54(14.027,10.027) 55(14.027,10.427) 56(14.027,10.827) 57(14.027,11.227) 58(14.027,11.627) 59(14.027,12.027) 60(14.027,12.427) 61(14.027,12.827) 62(14.027,13.227) 63(14.027,13.627) 64(14.027,14.027) 97(-1.627,14.027) 98(-1.627,13.627) 99(-1.627,13.227) 100(-1.627,12.827) 101(-1.627,12.427) 102(-1.627,12.027) 103(-1.627,11.627) 104(-1.627,11.227) 105(-1.627,10.827) 106(-1.627,10.427) 107(-1.627,10.027) 108(-1.627,9.627) 109(-1.627,9.227) 110(-1.627,8.827) 111(-1.627,8.427) 112(-1.627,8.027) 113(-1.627,7.627) 114(-1.627,7.227) 115(-1.627,6.827) 116(-1.627,6.427) 117(-1.627,6.027) 118(-1.627,5.627) 119(-1.627,5.227) 120(-1.627,4.827) 121(-1.627,4.427) 122(-1.627,4.027) 123(-1.627,3.627) 124(-1.627,3.227) 125(-1.627,2.827) 126(-1.627,2.427) 127(-1.627,2.027) 128(-1.627,1.627)
KC_FBMA-L10-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-201209-221LMA30_2P
  rect 0.838x1.397 smd: 1(0,0) 2(1.65,0)
KC_WCM-2012HS-900T_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,-0.8) 4(0,-0.8)
L03ESDL5V0CG3-2_SOT-523-3
  oval 0.406x0.787 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_1812-1806
  oval 1.016x3.708 smd: 1(0,0) 2(4.013,0)
LCN_DAN06-K4406-0102_204P
  round 1.6 hole 1.6 unplated: (-1.75,4.1)
  round 1.092 hole 1.092 unplated: (65.05,4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(0.3,8.2) 3(0.6,0) 4(0.9,8.2) 5(1.2,0) 6(1.5,8.2) 7(1.8,0) 8(2.1,8.2) 9(2.4,0) 10(2.7,8.2) 11(3,0) 12(3.3,8.2) 13(3.6,0) 14(3.9,8.2) 15(4.2,0) 16(4.5,8.2) 17(4.8,0) 18(5.1,8.2) 19(5.4,0) 20(5.7,8.2) 21(6,0) 22(6.3,8.2) 23(6.6,0) 24(6.9,8.2) 25(7.2,0) 26(7.5,8.2) 27(7.8,0) 28(8.1,8.2) 29(8.4,0) 30(8.7,8.2) 31(9,0) 32(9.3,8.2) 33(9.6,0) 34(9.9,8.2) 35(10.2,0) 36(10.5,8.2) 37(10.8,0) 38(11.1,8.2) 39(11.4,0) 40(11.7,8.2) 41(12,0) 42(12.3,8.2) 43(12.6,0) 44(12.9,8.2) 45(13.2,0) 46(13.5,8.2) 47(13.8,0) 48(14.1,8.2) 49(14.4,0) 50(14.7,8.2) 51(15,0) 52(15.3,8.2) 53(15.6,0) 54(15.9,8.2) 55(16.2,0) 56(16.5,8.2) 57(16.8,0) 58(17.1,8.2) 59(17.4,0) 60(17.7,8.2) 61(18,0) 62(18.3,8.2) 63(18.6,0) 64(18.9,8.2) 65(19.2,0) 66(19.5,8.2) 67(19.8,0) 68(20.1,8.2) 69(20.4,0) 70(20.7,8.2) 71(21,0) 72(21.3,8.2) 73(24,0) 74(24.3,8.2) 75(24.6,0) 76(24.9,8.2) 77(25.2,0) 78(25.5,8.2) 79(25.8,0) 80(26.1,8.2) 81(26.4,0) 82(26.7,8.2) 83(27,0) 84(27.3,8.2) 85(27.6,0) 86(27.9,8.2) 87(28.2,0) 88(28.5,8.2) 89(28.8,0) 90(29.1,8.2) 91(29.4,0) 92(29.7,8.2) 93(30,0) 94(30.3,8.2) 95(30.6,0) 96(30.9,8.2) 97(31.2,0) 98(31.5,8.2) 99(31.8,0) 100(32.1,8.2) 101(32.4,0) 102(32.7,8.2) 103(33,0) 104(33.3,8.2) 105(33.6,0) 106(33.9,8.2) 107(34.2,0) 108(34.5,8.2) 109(34.8,0) 110(35.1,8.2) 111(35.4,0) 112(35.7,8.2) 113(36,0) 114(36.3,8.2) 115(36.6,0) 116(36.9,8.2) 117(37.2,0) 118(37.5,8.2) 119(37.8,0) 120(38.1,8.2) 121(38.4,0) 122(38.7,8.2) 123(39,0) 124(39.3,8.2) 125(39.6,0) 126(39.9,8.2) 127(40.2,0) 128(40.5,8.2) 129(40.8,0) 130(41.1,8.2) 131(41.4,0) 132(41.7,8.2) 133(42,0) 134(42.3,8.2) 135(42.6,0) 136(42.9,8.2) 137(43.2,0) 138(43.5,8.2) 139(43.8,0) 140(44.1,8.2) 141(44.4,0) 142(44.7,8.2) 143(45,0) 144(45.3,8.2) 145(45.6,0) 146(45.9,8.2) 147(46.2,0) 148(46.5,8.2) 149(46.8,0) 150(47.1,8.2) 151(47.4,0) 152(47.7,8.2) 153(48,0) 154(48.3,8.2) 155(48.6,0) 156(48.9,8.2) 157(49.2,0) 158(49.5,8.2) 159(49.8,0) 160(50.1,8.2) 161(50.4,0) 162(50.7,8.2) 163(51,0) 164(51.3,8.2) 165(51.6,0) 166(51.9,8.2) 167(52.2,0) 168(52.5,8.2) 169(52.8,0) 170(53.1,8.2) 171(53.4,0) 172(53.7,8.2) 173(54,0) 174(54.3,8.2) 175(54.6,0) 176(54.9,8.2) 177(55.2,0) 178(55.5,8.2) 179(55.8,0) 180(56.1,8.2) 181(56.4,0) 182(56.7,8.2) 183(57,0) 184(57.3,8.2) 185(57.6,0) 186(57.9,8.2) 187(58.2,0) 188(58.5,8.2) 189(58.8,0) 190(59.1,8.2) 191(59.4,0) 192(59.7,8.2) 193(60,0) 194(60.3,8.2) 195(60.6,0) 196(60.9,8.2) 197(61.2,0) 198(61.5,8.2) 199(61.8,0) 200(62.1,8.2) 201(62.4,0) 202(62.7,8.2) 203(63,0) 204(63.3,8.2)
  rect 3.505x4.597 smd: 205(-1.15,16.1) 206(64.45,16.1)
LED_12-21C-T3D-CM2P1B18X-2C_3P
  rect 0.991x0.787 smd: 1(0,0) 2(-2.8,0)
  rect 0.991x0.61 smd: 3(-1.4,0.4)
LED_HT-210UD5-BP5_3P
  rect 1.194x0.787 smd: 1(0,0) 2(3,0)
  rect 0.889x0.991 smd: 3(1.5,0.5)
LOTES_AAA-BAT-054-K01_2P
  round 0.787 hole 0.787 unplated: (-14.5,-8)
  round 1.194 hole 1.194 unplated: (-14.5,8)
  rect 2.007x3.988 smd: 1(0,0) 2(-30.1,0)
MAG_MMD-12CE-R36M-M1L_2P
  rect 2.946x4.953 smd: 1(0,0) 2(10.815,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MDU1511RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MURAT_BLM15BB221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18BD102SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_LQM2MPN2R2NG0L_2P
  rect 0.787x1.803 smd: 1(0,0) 2(1.6,0)
P_M74VHC1GT125DF2G_SC70_5P
  oval 0.33x0.61 smd: 1(-0.65,-1.05) 2(0,-1.05) 3(0.65,-1.05) 4(0.65,1.05) 5(-0.65,1.05)
PANAS_ETQP3W2R2WFN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(-6.05,0)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS_HPF10052-06M000R_6P
  oval 0.305x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 2.489x1.905 smd: 7(7.65,-3.4) 8(-2.65,-3.4)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RTD2136R-CG_QFN48_6X6
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6.1) 26(4,6.1) 27(3.6,6.1) 28(3.2,6.1) 29(2.8,6.1) 30(2.4,6.1) 31(2,6.1) 32(1.6,6.1) 33(1.2,6.1) 34(0.8,6.1) 35(0.4,6.1) 36(0,6.1)
  oval 0.889x0.203 smd: 13(5.25,0.85) 14(5.25,1.25) 15(5.25,1.65) 16(5.25,2.05) 17(5.25,2.45) 18(5.25,2.85) 19(5.25,3.25) 20(5.25,3.65) 21(5.25,4.05) 22(5.25,4.45) 23(5.25,4.85) 24(5.25,5.25) 37(-0.85,5.25) 38(-0.85,4.85) 39(-0.85,4.45) 40(-0.85,4.05) 41(-0.85,3.65) 42(-0.85,3.25) 43(-0.85,2.85) 44(-0.85,2.45) 45(-0.85,2.05) 46(-0.85,1.65) 47(-0.85,1.25) 48(-0.85,0.85)
  rect 3.962x3.962 smd: 49(2.2,3.05)
RTL8106E-CG_QFN32_4X4
  oval 0.203x0.838 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.15) 18(2.4,4.15) 19(2,4.15) 20(1.6,4.15) 21(1.2,4.15) 22(0.8,4.15) 23(0.4,4.15) 24(0,4.15)
  oval 0.838x0.203 smd: 9(3.475,0.675) 10(3.475,1.075) 11(3.475,1.475) 12(3.475,1.875) 13(3.475,2.275) 14(3.475,2.675) 15(3.475,3.075) 16(3.475,3.475) 25(-0.675,3.475) 26(-0.675,3.075) 27(-0.675,2.675) 28(-0.675,2.275) 29(-0.675,1.875) 30(-0.675,1.475) 31(-0.675,1.075) 32(-0.675,0.675)
  rect 2.692x2.692 smd: 33(1.4,2.075)
RTS5179-GR_QFN24_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.261x2.261 smd: 25(1.25,2.05)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130456-311_8P
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  oval 1.753x3.15 hole 0.991x2.388: 9(-5.83,-12) 10(12.97,-12)
SANTA_193202-1_22P
  round 1.194 hole 1.194 unplated: (-31.47,-1.84) (-0.28,-1.84)
  round 1.092 hole 0.787: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.97,0) 9(-15.24,0) 10(-16.51,0) 11(-17.78,0) 12(-19.05,0) 13(-20.32,0) 14(-21.59,0) 15(-22.86,0) 16(-24.13,0) 17(-25.4,0) 18(-26.67,0) 19(-27.94,0) 20(-29.21,0) 21(-30.48,0) 22(-31.75,0)
  oval 1.803x3.2 hole 0.991x2.388: 23(2.2,-0.73) 24(-33.95,-0.73)
SANTA_202801-1_13P
  round 1.194 hole 1.194 unplated: (-19.78,-1.75) (1.02,-1.75)
  round 1.067 hole 0.711: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0)
  round 1.016 hole 0.61: 8(-13.83,1) 9(-14.83,0) 10(-15.83,1) 11(-16.83,0) 12(-17.83,1) 13(-18.83,0)
  custom 1.499x1.499 hole 2.311: 14(3.77,-0.75) 15(-22.53,-0.75)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SINGA_2SJ3080-000111F_6P-T
  oval 1.016x1.905 hole 0.61x1.499: 1(0,0) 2(-9.51,5.49) 3(0,7.8) 4(-9.51,8.39) 5(-9.51,0) 6(-9.51,2.74)
  oval 1.372x2.261 hole 0.61x1.499: 7(0,4.1)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIR818DP-T1_POWERPAK-SO8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SLG3NB274VTR_TQFN16_2X3
  oval 0.203x0.914 smd: 1(0,-0.013) 2(0.4,-0.013) 3(0.8,-0.013) 4(1.2,-0.013) 5(1.6,-0.013) 6(2,-0.013) 7(2.4,-0.013) 9(2.4,2.063) 10(2,2.063) 11(1.6,2.063) 12(1.2,2.063) 13(0.8,2.063) 14(0.4,2.063) 15(0,2.063)
  oval 0.914x0.203 smd: 8(2.738,1.025) 16(-0.338,1.025)
  rect 1.905x0.889 smd: 17(1.2,1.025)
SN74LVC1G06DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STARC_107K40-000001-G2_40P
  round 1.092 hole 1.092 unplated: (-2.3,-1.95) (21.8,-1.95)
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.549x3.404 smd: 41(-4.125,-5.85) 42(23.625,-5.85)
  rect 2.007x6.198 smd: 43(0.5,-7.65) 44(6,-7.65) 45(13.5,-7.65) 46(19,-7.65)
SUYIN_200028MR009G502ZL_9P
  round 1.499 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.499x3.302 hole 0.991x2.794: 10(19.125,0) 11(-3.125,0)
SW_SMT1-05-A_4P
  rect 0.61x0.991 smd: 1(0,0) 2(0,-4.4) 3(3.7,0) 4(3.7,-4.4)
  rect 0.457x0.991 smd: 5(-0.675,-2.2) 6(4.375,-2.2)
SY8003DFC_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.838 smd: 9(0.75,1.1)
SY8036DBC_DFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.388x1.575 smd: 11(1,1.55)
SY8206DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.077,-1.775)
  rect 0.813x1.168 smd: 10(0.137,-1.587)
T-SOL_143-2300302602_22P_RV
  round 1.194 hole 1.194 unplated: (0.5,-2.69) (20.5,-2.69)
  oval 0.508x1.854 smd: 1(0,0) 2(0.76,0) 3(1.52,0) 4(2.28,0) 5(3.8,0) 6(4.56,0) 7(5.32,0) 8(6.84,0) 9(7.6,0) 10(8.36,0) 11(9.12,0) 12(9.88,0) 13(11.4,0) 14(12.16,0) 15(12.92,0) 16(14.44,0) 17(15.2,0) 18(16.72,0) 19(19,0) 20(19.76,0) 21(20.52,0) 22(21.28,0)
  oval 1.092x2.997 hole 0.508x1.803: 23(-6.6,-23.63) 24(22.7,-23.63)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAI-T_VMPI0703AR-1R0M-Z01_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIYO_NRS4018T1R0NDGJ_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
TOKO_FDUE1040J-H-R36M-P3_4P
  custom 0.876x0.876 smd: 1(0,0) 4(13.411,0)
  rect 2.032x0.508 smd: 2(2.489,0) 3(10.922,0)
TOKO_FDVE1040-H-2R2M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS51622RSM_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.794x2.794 smd: 33(1.4,2.039)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
VISHAY_IHLP-2525CZ-01_2P
  rect 2.54x3.556 smd: 1(-2.857,0) 2(2.857,0)
W25Q64FVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000050_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_FSX3M-25PM20FDO_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.675V_DDR_VTT_ON: PR202.1 QD2.2 R2347.2 R2351.2 U2303.4
1.35V_B+: PC201.1 PC206.1 PC208.1 PC212.1 PL201.2 PQ200.5 PR208.1
3/5V_B+: PC105.1 PC112.1 PC113.1 PC114.1 PC115.1 PL102.2 PQ101.5 PQ103.5 PU100.12
3V_EN: PD101.2 PR100.1 PU100.6
3VALW_PCH: J513.2 U2304.13 U2304.14
3VS: J511.2 U2301.8 U2301.9
3VS_GATE: C2322.1 R2318.2 U2301.5
5V_EN: PD101.3 PR101.1 PU100.20
5VS: J510.2 U2301.13 U2301.14
5VS_GATE: C2309.1 R2313.2 U2301.3
+0.675VS: CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP203.1 R2314.1
+0.675VSP: PC205.1 PC211.1 PJP203.2 PU200.2 PU200.20
+1.2VSP_B+: PC1100.1 PC1101.1 PC1102.1 PL1100.1 PQ1100.5
+1.05V_PGOOD: PR308.2 PU300.2 UE1.122
+1.05VS: C43.1 C44.1 C50.1 C53.1 C57.1 C60.1 C61.1 C62.1 C66.1 C67.1 C76.1 C87.1 C88.1 CC14.1 CC15.1 CC28.1 CG2.1 JXDP1.43 JXDP1.44 L1.1 L2.1 L3.1 L4.1 L5.1 PC512.1 PJP300.2 PR526.1 PR528.1 PR530.1 PR533.2 R252.1 R253.2 R256.1 R267.1 R286.1 R2315.1 R2346.1 RC58.1 RC60.1 RC130.2 RP44.5 RP44.6 RP44.7 RP44.8 RP45.8 RP48.1 RP48.2 RP48.3 UC1.AC22 UC1.AE8 UC1.AE9 UC1.AE22 UC1.AE23 UC1.AF9 UC1.AF22 UC1.AG8 UC1.AG13 UC1.AG14 UC1.AG16 UC1.AG17 UC1.H11 UC1.H15 UC1.J11 UC1.J17 UC1.K9 UC1.L10 UC1.M9 UC1.N8 UC1.P9 UC1.R21 UC1.T21 UG1.3
+1.5VS: JMINI.6 JMINI.28 JMINI.48 PJP401.2 RA8.1 RC129.1 UC1.J15
+1.05VS_APLLOPI: C69.1 C70.1 L3.2 R267.2 UC1.AA21 UC1.W21
+1.05VS_ASATA3PLL: C63.1 C65.1 L2.2 RC126.2 RC131.2 UC1.B11
+1.05VS_AUSB3PLL: C58.1 C59.1 L1.2 RC91.1 UC1.B18 UC1.B27
+1.05VS_AXCK_DCB: C83.1 C84.1 L4.2 UC1.J18 UC1.K19
+1.05VS_AXCK_LCPLL: C85.1 C86.1 L5.2 RC13.2 UC1.A20
+1.05VSP: PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PJP300.1 PL301.2 PR305.1
+1.5VSP: PC400.1 PC402.1 PC404.1 PJP401.1 PL400.2 PR403.1
+1.5VSP_ON: PC403.1 PR401.1 PR404.1 PU400.7
+1.8VGA: L10.1 L11.1 L12.1 PJP1001.2 R39.2
+1.8VGAP: PC1003.1 PC1005.1 PJP1001.1 PR1001.1 PU1000.3 PU1000.4
+1.8VGS: CG1.1 J9.1 LV12.2 LV13.2 LV14.2 LV16.1 LV17.1 LV18.1 LV19.1 LV20.1 LV21.1 LV22.1 RV67.1 RV69.1 RV71.1 RV93.2 RV118.2 RV119.1 RV124.1 RV237.1 RV239.1 RV241.1 RV243.1 UG1.11
+1.8VS: J9.2 PJP601.2
+1.8VS_DAC: C23.1 C24.1 C25.1 C26.1 C89.2 L12.2 U4.5 U4.8 U4.11 U4.14
+1.8VS_RXVCC: C48.1 C80.1 C93.1 L10.2 U4.26 U4.29 U4.35 U4.38 U4.39
+1.8VS_RXVDD: C27.1 C28.1 C29.1 C30.1 C31.1 L11.2 U4.15 U4.17 U4.28 U4.37 U4.49 U4.52
+1.8VSP: PC600.1 PC602.1 PC604.1 PJP601.1 PL600.2 PR603.1
+1.8VSP_ON: PC603.1 PR601.1 PR604.1 PU600.7
+1.35V: C35.1 C36.1 C37.1 C38.1 C39.1 C40.2 C41.1 C42.1 C43.2 C45.1 C72.1 C74.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD23.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD62.2 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP200.2 PJP201.2 QD2.1 RC14.1 RC15.1 RC16.1 RD3.1 U2303.5 UC1.AH26 UC1.AJ31 UC1.AJ33 UC1.AJ37 UC1.AN33 UC1.AP43 UC1.AR48 UC1.AY35 UC1.AY40 UC1.AY44 UC1.AY50
+1.35V_MEM_GFX: CV1.1 CV3.1 CV4.1 CV5.1 CV6.1 CV7.1 CV8.1 CV9.1 CV10.1 CV11.1 CV12.1 CV14.1 CV15.1 CV16.1 CV17.1 CV18.1 CV19.1 CV21.1 CV24.1 CV26.1 CV28.1 CV30.1 CV32.1 CV34.1 CV36.1 CV38.1 CV40.1 CV41.1 CV42.1 CV59.1 CV60.1 CV61.1 CV62.1 CV63.1 CV64.1 CV65.1 CV66.1 CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV135.1 CV136.1 CV137.1 CV138.1 CV139.1 CV140.1 CV141.1 CV142.1 CV143.1 CV144.1 CV145.1 CV152.1 CV153.1 CV154.1 CV155.1 CV156.1 CV280.1 CV281.1 CV283.1 CV284.1 CV285.1 CV286.1 CV287.1 CV288.1 CV290.1 CV291.1 CV292.1 CV293.1 CV294.1 CV295.1 CV296.1 CV297.1 CV298.1 CV299.1 CV301.1 CV302.1 CV303.1 CV304.1 CV305.1 CV306.1 CV307.1 CV308.1 CV310.1 CV311.1 CV312.1 CV313.1 CV315.1 CV316.1 CV318.1 CV319.1 CV328.1 CV330.1 CV350.1 CV352.1 CV354.1 CV356.1 CV368.1 CV369.1 CV370.1 CV371.1 CV372.1 CV373.1 CV374.1 CV375.1 CV376.1 CV377.1 CV378.1 CV379.1 CV380.1 CV381.1 CV382.1 CV383.1 CV384.1 CV385.1 CV386.1 CV388.1 CV389.1 CV391.1 CV392.1 CV393.1 CV394.1 CV396.1 CV401.1 JP9.1 RV1.1 RV3.1 RV6.1 RV8.1 RV10.1 RV12.1 RV14.1 RV16.1 RV19.1 RV21.1 RV23.1 RV27.1 RV28.1 RV32.1 RV35.1 RV37.1 RV38.1 RV40.1 RV42.1 RV43.1 RV44.1 RV45.1 RV46.1 RV47.1 RV48.1 RV49.1 RV138.1 RV139.1 RV140.1 RV141.1 RV142.1 RV183.1 RV185.1 RV191.1 RV193.1 RV195.1 RV197.1 UV1.AC7 UV1.AD11 UV1.AF7 UV1.AG10 UV1.AJ7 UV1.AK8 UV1.AL9 UV1.G11 UV1.G14 UV1.G17 UV1.G20 UV1.G23 UV1.G26 UV1.G29 UV1.H10 UV1.J7 UV1.J9 UV1.K8 UV1.K11 UV1.K13 UV1.L7 UV1.L12 UV1.L16 UV1.L21 UV1.L23 UV1.L26 UV1.M11 UV1.N11 UV1.P7 UV1.R11 UV1.U7 UV1.U11 UV1.Y7 UV1.Y11 UV3.B1 UV3.B3 UV3.B12 UV3.B14 UV3.C5 UV3.C10 UV3.D1 UV3.D3 UV3.D11 UV3.D12 UV3.D13 UV3.D14 UV3.E5 UV3.E10 UV3.F1 UV3.F3 UV3.F12 UV3.F14 UV3.G1 UV3.G2 UV3.G4 UV3.G11 UV3.G13 UV3.G14 UV3.H3 UV3.H12 UV3.J1 UV3.K3 UV3.K12 UV3.L1 UV3.L2 UV3.L4 UV3.L11 UV3.L13 UV3.L14 UV3.M1 UV3.M3 UV3.M12 UV3.M14 UV3.N5 UV3.N10 UV3.P1 UV3.P2 UV3.P3 UV3.P11 UV3.P12 UV3.P14 UV3.R5 UV3.R10 UV3.T1 UV3.T3 UV3.T12 UV3.T14 UV4.B1 UV4.B3 UV4.B12 UV4.B14 UV4.C5 UV4.C10 UV4.D1 UV4.D3 UV4.D11 UV4.D12 UV4.D13 UV4.D14 UV4.E5 UV4.E10 UV4.F1 UV4.F3 UV4.F12 UV4.F14 UV4.G1 UV4.G2 UV4.G4 UV4.G11 UV4.G13 UV4.G14 UV4.H3 UV4.H12 UV4.K3 UV4.K12 UV4.L1 UV4.L2 UV4.L4 UV4.L11 UV4.L13 UV4.L14 UV4.M1 UV4.M3 UV4.M12 UV4.M14 UV4.N5 UV4.N10 UV4.P1 UV4.P2 UV4.P3 UV4.P11 UV4.P12 UV4.P14 UV4.R5 UV4.R10 UV4.T1 UV4.T3 UV4.T12 UV4.T14 UV5.B1 UV5.B3 UV5.B12 UV5.B14 UV5.C5 UV5.C10 UV5.D1 UV5.D3 UV5.D11 UV5.D12 UV5.D13 UV5.D14 UV5.E5 UV5.E10 UV5.F1 UV5.F3 UV5.F12 UV5.F14 UV5.G1 UV5.G2 UV5.G4 UV5.G11 UV5.G13 UV5.G14 UV5.H3 UV5.H12 UV5.J1 UV5.K3 UV5.K12 UV5.L1 UV5.L2 UV5.L4 UV5.L11 UV5.L13 UV5.L14 UV5.M1 UV5.M3 UV5.M12 UV5.M14 UV5.N5 UV5.N10 UV5.P1 UV5.P2 UV5.P3 UV5.P11 UV5.P12 UV5.P14 UV5.R5 UV5.R10 UV5.T1 UV5.T3 UV5.T12 UV5.T14 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D13 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P2 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV7.B1 UV7.B3 UV7.B12 UV7.B14 UV7.C5 UV7.C10 UV7.D1 UV7.D3 UV7.D11 UV7.D12 UV7.D13 UV7.D14 UV7.E5 UV7.E10 UV7.F1 UV7.F3 UV7.F12 UV7.F14 UV7.G1 UV7.G2 UV7.G4 UV7.G11 UV7.G13 UV7.G14 UV7.H3 UV7.H12 UV7.J1 UV7.K3 UV7.K12 UV7.L1 UV7.L2 UV7.L4 UV7.L11 UV7.L13 UV7.L14 UV7.M1 UV7.M3 UV7.M12 UV7.M14 UV7.N5 UV7.N10 UV7.P1 UV7.P2 UV7.P3 UV7.P11 UV7.P12 UV7.P14 UV7.R5 UV7.R10 UV7.T1 UV7.T3 UV7.T12 UV7.T14 UV8.B1 UV8.B3 UV8.B12 UV8.B14 UV8.C5 UV8.C10 UV8.D1 UV8.D3 UV8.D11 UV8.D12 UV8.D13 UV8.D14 UV8.E5 UV8.E10 UV8.F1 UV8.F3 UV8.F12 UV8.F14 UV8.G1 UV8.G2 UV8.G4 UV8.G11 UV8.G13 UV8.G14 UV8.H3 UV8.H12 UV8.K3 UV8.K12 UV8.L1 UV8.L2 UV8.L4 UV8.L11 UV8.L13 UV8.L14 UV8.M1 UV8.M3 UV8.M12 UV8.M14 UV8.N5 UV8.N10 UV8.P1 UV8.P2 UV8.P3 UV8.P11 UV8.P12 UV8.P14 UV8.R5 UV8.R10 UV8.T1 UV8.T3 UV8.T12 UV8.T14 UV9.B1 UV9.B3 UV9.B12 UV9.B14 UV9.C5 UV9.C10 UV9.D1 UV9.D3 UV9.D11 UV9.D12 UV9.D13 UV9.D14 UV9.E5 UV9.E10 UV9.F1 UV9.F3 UV9.F12 UV9.F14 UV9.G1 UV9.G2 UV9.G4 UV9.G11 UV9.G13 UV9.G14 UV9.H3 UV9.H12 UV9.J1 UV9.K3 UV9.K12 UV9.L1 UV9.L2 UV9.L4 UV9.L11 UV9.L13 UV9.L14 UV9.M1 UV9.M3 UV9.M12 UV9.M14 UV9.N5 UV9.N10 UV9.P1 UV9.P2 UV9.P3 UV9.P11 UV9.P12 UV9.P14 UV9.R5 UV9.R10 UV9.T1 UV9.T3 UV9.T12 UV9.T14 UV10.B1 UV10.B3 UV10.B12 UV10.B14 UV10.C5 UV10.C10 UV10.D1 UV10.D3 UV10.D11 UV10.D12 UV10.D13 UV10.D14 UV10.E5 UV10.E10 UV10.F1 UV10.F3 UV10.F12 UV10.F14 UV10.G1 UV10.G2 UV10.G4 UV10.G11 UV10.G13 UV10.G14 UV10.H3 UV10.H12 UV10.K3 UV10.K12 UV10.L1 UV10.L2 UV10.L4 UV10.L11 UV10.L13 UV10.L14 UV10.M1 UV10.M3 UV10.M12 UV10.M14 UV10.N5 UV10.N10 UV10.P1 UV10.P2 UV10.P3 UV10.P11 UV10.P12 UV10.P14 UV10.R5 UV10.R10 UV10.T1 UV10.T3 UV10.T12 UV10.T14
+1.35VGPUP: PC1108.1 PJP1100.1 PJP1101.1 PL1101.2 PR1107.2
+1.35VP: PC213.1 PJP200.1 PJP201.1 PL200.1 PR207.2 PU200.5 PU200.19
+1.35VS_VGA: JP9.2 PJP1100.2 PJP1101.2
+3V_WLAN: CM40.1 CM43.1 CM46.2 CM47.1 CM48.2 JMINI.2 JMINI.24 JMINI.39 JMINI.41 JMINI.52 RM25.2 RM26.2
+3VALW: C2311.1 C2313.1 C2316.1 C2318.1 CE1.1 CE2.1 CE5.2 CE6.2 CG10.1 CL38.1 CL39.1 JP3.2 JPWR.1 LE1.1 PC313.1 PC1205.1 PJP100.2 PJP102.2 PJP400.1 PJP600.1 PJP1000.1 PJP1301.2 PR3.2 PR16.2 PR28.1 PU300.7 PU1200.7 RE3.2 RE8.2 RE11.2 RE71.1 RP36.5 RP36.6 RP36.7 RP36.8 RV109.1 U2301.6 U2301.7 U2304.1 U2304.2 U2304.4 UE1.9 UE1.22 UE1.33 UE1.96 UE1.125 UG1.2 UL2.4 UL2.5
+3VALW_PCH: C75.2 C78.1 C81.1 C2310.1 C2312.1 J513.1 QH1.2 QH1.5 R264.1 R2329.1 R2330.1 RC27.1 RC28.1 RC29.1 RC31.1 RC32.1 RC34.1 RC64.2 RC104.2 RC110.2 RC120.1 RC124.1 RC125.1 RC127.1 RP40.5 RP40.6 RP40.7 RP40.8 RP49.7 RP49.8 RP55.5 RP55.6 RP55.7 RP55.8 UC1.AA9 UC1.AC9 UC1.AE20 UC1.AE21 UC1.AH10
+3VALW_PCH_GATE: C2314.1 R416.2 U2304.3
+3VALWP: PC101.1 PC102.1 PJP100.1 PJP102.1 PL100.2 PR109.1
+3VGS: CV85.2 CV101.1 CV102.1 CV187.1 CV188.1 CV189.1 CV190.1 CV326.2 JP8.1 PR826.1 PR828.1 PR835.1 PR837.1 PR839.1 PR1213.1 QV15.2 QV15.5 QV22.1 QV28.2 RP47.1 RP47.2 RP47.3 RP60.1 RP60.3 RP60.4 RV73.1 RV74.1 RV75.1 RV76.1 RV81.1 RV82.1 RV83.1 RV85.1 RV90.1 RV91.1 RV96.2 RV98.2 RV105.1 RV199.1 RV235.1 UV1.AF23 UV1.AF24 UV1.AG23 UV1.AG24 UV13.5 UV14.1
+3VLP: CG4.1 JP12.1 PC109.1 PU100.3 RE49.2 UE1.111 UG1.15
+3VS: C44.2 C68.1 C71.1 C73.1 C82.1 C92.1 C2323.1 C2324.1 C2327.1 CA57.1 CA58.1 CA59.1 CA60.1 CC11.1 CC13.1 CD30.1 CD31.1 CD60.1 CD61.1 CD62.1 CD63.1 CE15.1 CM45.1 CR1.1 CR2.1 CX1.1 CX7.1 CX9.1 J511.1 JDIMM1.199 JDIMM2.199 JHDD.8 JHDD.9 JLVDS.26 JP8.2 JTP.1 PR308.1 PR516.1 PR524.1 PR808.1 PR842.2 PR1110.1 PU501.20 PU501.21 Q2.2 Q2.5 Q25.3 QC1.2 QC1.5 QD18.2 QD19.2 QM30.2 QV22.3 R18.1 R23.1 R24.2 R35.1 R38.2 R41.1 R2331.1 R2332.1 R2334.1 R2335.1 RA1.1 RA2.1 RA7.1 RA9.1 RC3.1 RC9.2 RC11.2 RC36.1 RC73.1 RC74.1 RC75.1 RC76.1 RC77.1 RC98.2 RC100.1 RC102.1 RC106.1 RC107.2 RC108.1 RC111.1 RC112.1 RC118.1 RC119.1 RC121.1 RC128.1 RC362.1 RD12.2 RD45.1 RD47.1 RE9.1 RE10.1 RE50.1 RL33.1 RL37.2 RM25.1 RM26.1 RM110.1 RP1.1 RP1.2 RP1.3 RP1.4 RP37.6 RP37.7 RP37.8 RP42.1 RP42.2 RP42.3 RP42.4 RP43.1 RP43.2 RP51.6 RP51.8 RP52.5 RP52.6 RP52.7 RP52.8 RP53.5 RP53.6 RP53.7 RP53.8 RP54.5 RP54.6 RP54.7 RP54.8 RS7.1 RX4.1 RX27.1 RX29.1 U4.51 U2302.8 UA1.1 UA1.9 UA1.36 UC1.K14 UC1.K16 UC1.T9 UC1.U8 UC1.V8 UC1.W9 UC1.Y8 UC3.5 UC4.14 UD1.5 UE2.5 UR1.4 UX1.4 UX1.5
+3VS_6511: C20.1 C21.1 C22.1 Q25.1 R23.2 U4.16 U4.46 U4.54
+3VS_CAM: JLVDS.29 RX27.2
+3VS_RT: CX10.1 LX7.2 LX8.2 QX6.2 QX6.5 RX4.2 RX30.1 RX168.1 RX169.1 UX2.5
+5V_HDD: CS5.1 CS6.1 CS7.1 JHDD.14 JHDD.15 JHDD.16 JP13.1
+5V_PVDD: CA53.1 CA54.1 CA55.1 CA56.1 RV54.2 UA1.41 UA1.46
+5V_USB_PWR1: CI1.1 CI2.1 CI40.1 JUSB1.1 UI3.6 UI3.7 UI3.8
+5V_USB_PWR2: CI8.1 CI9.1 CI43.1 JUSB2.1 UI2.6 UI2.7 UI2.8
+5V_USB_PWR3: CI19.1 CI20.1 CI44.1 JUSB3.1 UI4.6 UI4.7 UI4.8
+5V_USB_PWR4: JDB.1 JDB.2 JDB.3 UI5.6 UI5.7 UI5.8
+5VA: CA51.1 CA71.1 RV59.2 UA1.26
+5VALW: C2305.1 C2306.1 CI6.1 CI7.1 CI12.1 CI14.1 CI18.1 CI21.1 CI22.1 CI23.1 CI27.1 CI30.1 CI31.1 LED1.2 LED3.1 LED4.2 PC204.2 PC1001.1 PC1105.1 PJP101.2 PJP103.2 PR8.1 PR206.1 PR814.2 PR822.2 PR824.1 PU200.12 PU1000.6 PU1100.7 R10.1 R2347.1 RD46.1 RV107.1 U2301.1 U2301.2 U2301.4 UI2.2 UI2.3 UI3.2 UI3.3 UI4.2 UI4.3 UI5.2 UI5.3
+5VALWP: PC107.1 PC108.2 PJP101.1 PJP103.1 PL101.2 PR104.2 PU100.14
+5VS: C2307.1 C2308.1 CE25.1 CS13.1 DE2.2 J510.1 JP7.1 JP13.2 LED2.2 PC503.1 PR519.1 PU502.2 Q1.2 QS2.1 QS2.2 QS2.5 QS2.6 RE60.1 RV54.1 RV59.1 RX28.1 UE3.1 UE3.2
+5VS_CRT: C9.2 CRTF1.1 DE2.1 R27.1 R28.1 RE4.2 U1.5 U2.5
+5VS_ODD: CS10.1 CS11.1 CS12.1 JODD.9 JODD.10 JP7.2 QS2.4
+5VS_TOUCH: CX6.1 JTOUCH.1 RX24.1 RX28.2 RX29.2
+AVCC33: CX31.1 CX33.1 CX35.1 LX8.1 UX4.5
+AVDD: CV75.1 CV76.1 CV77.1 LV12.1 UV1.AD34
+DVCC33: CX34.1 CX36.1 CX40.1 CX41.1 CX45.1 LX7.1 RP56.5 RP56.6 RP56.7 RP56.8 RP57.7 RP57.8 UX4.18 UX4.22
+V18R: CE16.1 UE1.124
+VCC_3IN1: CR7.1 CR8.1 JREAD.4 JREAD.11 UR1.5
+VCC_PWR_SRC: PC502.2 PC515.1 PC516.1 PC517.1 PC518.1 PC519.1 PC521.1 PL501.1 PR508.1 PU502.5
+VCCHDA: C77.1 RC127.2 RC128.2 RC129.2 UC1.AH14
+VCCIO_OUT: R245.2
+VCCIO_OUT_R: R245.1 UC1.A59
+VCCIOA_OUT: RC71.1 RC78.1 UC1.E20
+VCCRTCEXT: C52.1 UC1.AE7
+VDD1DI: CV78.1 CV79.1 CV80.1 LV13.1 UV1.AC33
+VDD_MEM15_REFDA: CV220.1 RV139.2 RV146.1 UV1.L18
+VDD_MEM15_REFDB: CV223.1 RV141.2 RV148.1 UV1.Y12
+VDD_MEM15_REFSA: CV221.1 RV140.2 RV147.1 UV1.L20
+VDD_MEM15_REFSB: CV224.1 RV142.2 RV149.1 UV1.AA12
+VDDC_CT: CV170.1 CV171.1 CV172.1 CV173.1 CV174.1 LV19.2 UV1.AF26 UV1.AF27 UV1.AG26 UV1.AG27
+VDDCI: CV203.1 CV204.1 CV205.1 CV206.1 CV207.1 CV208.1 CV209.1 CV210.1 CV211.1 CV212.1 CV213.1 CV214.1 CV322.1 CV323.1 CV324.1 CV325.1 LV25.1 LV26.1 PJP1200.2 RV215.1 UV1.AA13 UV1.AB13 UV1.AC12 UV1.AC15 UV1.AD13 UV1.AD16 UV1.M15 UV1.M16 UV1.M18 UV1.M23 UV1.N13 UV1.N15 UV1.N17 UV1.N20 UV1.N22 UV1.R12 UV1.R13 UV1.R16 UV1.T12 UV1.T15 UV1.V15 UV1.Y13
+VDDCIP: PC1201.1 PC1206.1 PC1207.1 PC1211.1 PJP1200.1 PL1200.2 PR1208.1
+VDDR4: CV193.1 CV194.1 LV20.2 UV1.AD12 UV1.AF11 UV1.AF12 UV1.AF13 UV1.AF15 UV1.AG11 UV1.AG13 UV1.AG15
