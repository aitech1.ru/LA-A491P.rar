# Allegro board LAA491PR10-0624.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.1 C10.2 C11.2 C12.2 C13.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C35.2 C36.2 C37.2 C38.2 C39.2 C41.2 C42.2 C45.2 C46.2 C48.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.1 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C90.1 C91.2 C92.2 C93.2 C95.2 C96.2 C411.2 C2305.2 C2306.2 C2307.2 C2308.2 C2309.2 C2310.2 C2311.2 C2312.2 C2313.2 C2314.2 C2316.2 C2318.2 C2322.2 C2323.2 C2324.2 C2326.2 C2327.2 C5212.2 CA21.2 CA22.2 CA25.1 CA29.2 CA30.2 CA31.2 CA32.2 CA53.2 CA54.2 CA55.2 CA56.2 CA57.2 CA58.2 CA59.2 CA60.2 CA64.1 CA69.2 CA74.2 CC1.1 CC2.1 CC3.1 CC4.1 CC5.2 CC6.1 CC7.1 CC11.2 CC13.2 CC14.2 CC15.2 CC16.2 CC17.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC33.2 CC34.2 CC35.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD63.2 CD64.2 CE1.2 CE2.2 CE5.1 CE6.1 CE8.2 CE11.2 CE12.2 CE15.2 CE16.2 CE18.1 CE19.2 CE20.2 CE22.2 CE23.2 CE24.2 CE25.2 CE26.2 CE27.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE33.2 CE34.2 CE35.2 CE36.2 CG1.2 CG2.2 CG3.2 CG4.2 CG5.2 CG6.2 CG7.2 CG8.2 CG9.2 CG10.2 CG11.2 CI1.2 CI2.2 CI6.2 CI7.2 CI8.2 CI9.2 CI12.2 CI13.2 CI14.2 CI15.2 CI16.2 CI17.2 CI18.2 CI19.2 CI20.2 CI21.2 CI22.2 CI23.2 CI24.2 CI25.2 CI26.2 CI27.2 CI30.2 CI31.2 CI32.2 CI40.2 CI43.2 CI44.2 CL15.2 CL19.2 CL20.2 CL22.2 CL26.2 CL33.2 CL34.2 CL35.2 CL36.1 CL37.1 CL38.2 CL39.2 CL41.1 CL42.2 CL43.2 CL44.2 CM40.2 CM43.2 CM46.1 CM47.2 CM48.1 CMOS1.1 CR1.2 CR2.2 CR3.1 CR4.1 CR5.2 CR6.2 CR7.2 CR8.2 CR9.2 CR10.2 CR11.2 CS5.2 CS6.2 CS7.2 CS10.2 CS11.2 CS12.2 CS13.2 CS16.2 CS17.2 CV1.2 CV3.2 CV4.2 CV5.2 CV6.2 CV7.2 CV8.2 CV9.2 CV10.2 CV11.2 CV12.2 CV13.2 CV14.2 CV15.2 CV16.2 CV17.2 CV20.2 CV22.2 CV23.2 CV25.2 CV27.2 CV29.2 CV31.2 CV33.2 CV35.2 CV37.2 CV39.2 CV41.2 CV42.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV83.2 CV84.2 CV85.1 CV86.2 CV87.2 CV88.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV97.2 CV101.2 CV102.2 CV103.2 CV108.2 CV109.2 CV110.2 CV111.2 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV129.2 CV130.2 CV131.2 CV132.2 CV133.2 CV134.2 CV135.2 CV136.2 CV137.2 CV138.2 CV139.2 CV140.2 CV141.2 CV142.2 CV143.2 CV144.2 CV145.2 CV146.2 CV147.2 CV148.2 CV149.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV170.2 CV171.2 CV172.2 CV173.2 CV174.2 CV187.2 CV188.2 CV189.2 CV190.2 CV193.2 CV194.2 CV195.2 CV196.2 CV197.2 CV198.2 CV199.2 CV200.2 CV201.2 CV202.2 CV203.2 CV204.2 CV205.2 CV206.2 CV207.2 CV208.2 CV209.2 CV210.2 CV211.2 CV212.2 CV213.2 CV214.2 CV215.2 CV216.2 CV217.2 CV220.2 CV221.2 CV222.2 CV223.2 CV224.2 CV280.2 CV281.2 CV283.2 CV284.2 CV285.2 CV286.2 CV287.2 CV288.2 CV290.2 CV291.2 CV292.2 CV293.2 CV294.2 CV295.2 CV296.2 CV297.2 CV298.2 CV299.2 CV301.2 CV302.2 CV303.2 CV304.2 CV305.2 CV306.2 CV307.2 CV308.2 CV310.2 CV311.2 CV312.2 CV313.2 CV315.2 CV316.2 CV318.2 CV319.2 CV322.2 CV323.2 CV324.2 CV325.2 CV326.1 CV327.2 CV329.2 CV331.2 CV332.2 CV333.2 CV335.2 CV349.2 CV351.2 CV353.2 CV355.2 CV368.2 CV369.2 CV370.2 CV371.2 CV372.2 CV373.2 CV374.2 CV375.2 CV376.2 CV377.2 CV378.2 CV379.2 CV380.2 CV381.2 CV382.2 CV383.2 CV384.2 CV385.2 CV386.2 CV387.2 CV390.2 CV391.2 CV392.2 CV395.2 CV397.2 CV398.2 CV399.2 CV400.2 CX1.2 CX2.2 CX3.2 CX5.2 CX6.2 CX7.2 CX8.2 CX9.2 CX10.2 CX11.2 CX31.2 CX32.2 CX33.2 CX34.2 CX35.2 CX36.2 CX37.2 CX40.2 CX41.2 CX45.2 CX47.2 CX48.2 DA10.1 DA12.1 DE1.1 DE3.1 DE4.1 DE5.1 DI1.3 DI1.8 DI2.1 DI4.3 DI4.8 DI5.1 DI7.1 H2.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H31.1(TP-1) H32.1(TP-1) H33.1(TP-1) H34.1(TP-1) JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDB.6 JDB.7 JDB.8 JDB.9 JDB.10 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JFAN.3 JFAN.4 JFAN.5 JHDD.1 JHDD.4 JHDD.7 JHDD.11 JHDD.13 JHDD.17 JHDD.19 JHDD.23 JHDD.24 JKB.31 JKB.32 JLAN.9 JLAN.10 JLVDS.3 JLVDS.6 JLVDS.9 JLVDS.12 JLVDS.15 JLVDS.31 JLVDS.41 JLVDS.42 JLVDS.43 JLVDS.44 JLVDS.45 JLVDS.46 JMINI.4 JMINI.9 JMINI.15 JMINI.18 JMINI.21 JMINI.26 JMINI.27 JMINI.29 JMINI.34 JMINI.35 JMINI.40 JMINI.43 JMINI.50 JMINI.53 JMINI.54 JODD.1 JODD.4 JODD.7 JODD.12 JODD.13 JODD.14 JODD.15 JPWR.4 JPWR.5 JPWR.6 JREAD.2 JREAD.9 JREAD.16 JREAD.17 JREAD.21 JREAD.23 JREAD.24 JRTC.2 JSPK.5 JSPK.6 JTOUCH.4 JTOUCH.5 JTOUCH.7 JTOUCH.8 JTP.4 JTP.7 JTP.8 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.5 JUSB3.6 JUSB3.7 JUSB3.8 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 LE2.1 ME1.1 PBATT.1 PBATT.2 PBATT.4 PBATT.10 PBATT.11 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC7.2 PC8.2 PC13.1 PC15.2 PC100.2 PC101.2 PC103.2 PC105.2 PC106.2 PC107.2 PC109.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC201.2 PC202.2 PC203.2 PC204.1 PC205.2 PC206.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC300.2 PC301.2 PC303.2 PC304.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC400.2 PC401.2 PC402.2 PC403.2 PC405.2 PC502.1 PC503.2 PC504.2 PC505.2 PC506.1 PC507.2 PC508.1 PC509.2 PC512.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC521.2 PC522.2 PC523.2 PC600.2 PC601.2 PC602.2 PC603.2 PC605.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC711.1 PC712.2 PC713.2 PC714.2 PC716.2 PC718.2 PC719.2 PC720.1 PC724.2 PC803.2 PC804.2 PC805.2 PC808.2 PC810.2 PC811.2 PC813.1 PC816.1 PC821.1 PC831.2 PC832.2 PC835.2 PC836.2 PC837.2 PC838.2 PC839.2 PC840.2 PC841.2 PC842.2 PC843.2 PC844.2 PC845.2 PC846.2 PC847.2 PC848.2 PC849.2 PC850.2 PC851.2 PC852.2 PC853.2 PC854.2 PC855.2 PC856.2 PC857.2 PC858.2 PC859.2 PC860.2 PC861.2 PC862.2 PC863.2 PC864.2 PC865.2 PC866.2 PC867.2 PC868.2 PC869.2 PC870.2 PC871.2 PC872.2 PC873.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC1001.2 PC1002.2 PC1004.2 PC1005.2 PC1100.2 PC1101.2 PC1102.2 PC1104.2 PC1105.2 PC1106.2 PC1108.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1209.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1307.2 PC1308.2 PD1.2 PD2.1 PD3.1 PD101.1 PL4.2 PQ1.1 PQ1.4 PQ2.1 PQ2.4 PQ3.1 PQ3.4 PQ4.3 PQ5.3 PQ102.1 PQ102.2 PQ102.3 PQ104.1 PQ104.2 PQ104.3 PQ201.1 PQ201.2 PQ201.3 PQ705.1 PQ705.2 PQ705.3 PQ706.3 PQ708.3 PQ801.1 PQ801.2 PQ801.3 PQ802.1 PQ802.2 PQ802.3 PQ1101.1 PQ1101.2 PQ1101.3 PQ1201.3 PR2.2 PR9.1 PR10.1 PR26.1 PR29.2 PR32.2 PR33.1 PR105.2 PR106.2 PR107.1 PR108.2 PR114.2 PR203.2 PR204.2 PR301.2 PR306.2 PR307.2 PR402.2 PR404.2 PR503.1 PR505.1 PR506.1 PR509.1 PR510.2 PR512.1 PR513.1 PR534.2 PR602.2 PR604.2 PR711.1 PR712.2 PR722.2 PR724.1 PR804.1 PR805.2 PR811.1 PR815.2 PR819.1 PR833.2 PR834.1 PR836.1 PR838.1 PR840.1 PR1002.2 PR1004.2 PR1102.1 PR1105.2 PR1108.2 PR1201.2 PR1202.2 PR1204.2 PR1214.2 PR1301.2 PR1304.2 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.9 PU400.4 PU400.8 PU400.9 PU501.19 PU501.22 PU501.29 PU501.33 PU502.3 PU502.9 PU600.4 PU600.8 PU600.9 PU701.14 PU701.21 PU800.17 PU800.29 PU1000.1 PU1100.11 PU1200.9 PU1300.11 Q3.3 Q4.3 Q8.3 Q2307.3 Q2308.3 QC3.3 QD20.3 QS3.3 QV14.1 QV14.4 QV24.3 QV25.3 QX1.3 R2.2 R12.1 R15.2 R16.2 R25.2 R26.2 R29.2 R30.2 R31.2 R32.2 R33.2 R34.2 R159.2 R255.1 R2338.2 R2351.1 RA19.2 RA29.2 RA30.2 RA31.2 RA32.2 RA81.1 RC2.2 RC20.2 RC21.2 RC22.2 RC23.2 RC24.2 RC25.2 RC66.2 RC68.2 RC69.2 RC70.2 RC84.1 RC87.1 RC88.2 RC89.2 RC90.2 RC99.2 RC101.2 RC113.2 RC116.2 RC122.2 RC123.2 RC132.2 RC133.1 RC134.2 RC135.2 RC138.2 RC163.2 RD6.1 RD7.1 RD13.2 RD50.2 RD52.2 RE1.1 RE2.1 RE5.1 RE18.2 RE47.1 RE326.2 RL27.1 RL31.1 RL35.1 RM11.1 RP41.5 RP41.6 RP41.7 RP41.8 RP45.6 RP45.7 RP47.4 RP51.5 RP51.7 RR1.2 RV2.2 RV4.2 RV5.2 RV7.2 RV9.2 RV11.2 RV13.2 RV15.2 RV17.2 RV20.2 RV22.2 RV24.2 RV25.1 RV26.1 RV29.2 RV30.1 RV31.1 RV33.2 RV34.2 RV36.2 RV39.2 RV41.2 RV64.1 RV66.2 RV68.1 RV70.1 RV84.2 RV89.1 RV95.2 RV122.2 RV123.2 RV125.2 RV127.2 RV133.1 RV136.2 RV137.2 RV145.1 RV146.2 RV147.2 RV148.2 RV149.2 RV162.1 RV163.1 RV169.1 RV171.1 RV181.2 RV184.2 RV186.2 RV192.2 RV194.2 RV196.2 RV201.2 RV204.2 RV206.1 RV207.2 RV236.2 RV238.2 RV240.2 RV242.2 RV248.1 RX5.1 RX9.2 RX20.2 RX23.2 RX25.2 RX26.2 RX33.2 RX35.2 RX36.2 RX170.2 RX171.2 SW1.1 SW1.2 SW1.5 SW1.6 SW2.1 SW2.2 SW2.5 SW2.6 U1.3 U2.3 U4.36 U4.57 U2301.11 U2301.15 U2302.4 U2303.3 U2304.11 U2304.15 UA1.4 UA1.49 UC1.A11 UC1.A14 UC1.A18 UC1.A24 UC1.A28 UC1.A32 UC1.A36 UC1.A40 UC1.A44 UC1.A48 UC1.A52 UC1.A56 UC1.AA1 UC1.AA58 UC1.AB7 UC1.AB10 UC1.AB20 UC1.AB22 UC1.AC61 UC1.AD3 UC1.AD21 UC1.AD63 UC1.AE5 UC1.AE10 UC1.AE58 UC1.AF11 UC1.AF12 UC1.AF14 UC1.AF15 UC1.AF17 UC1.AF18 UC1.AG1 UC1.AG11 UC1.AG21 UC1.AG23 UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 UC1.AH16 UC1.AH17 UC1.AH19 UC1.AH20 UC1.AH22 UC1.AH24 UC1.AH28 UC1.AH30 UC1.AH32 UC1.AH34 UC1.AH36 UC1.AH38 UC1.AH40 UC1.AH42 UC1.AH44 UC1.AH46 UC1.AH49 UC1.AH51 UC1.AH53 UC1.AH55 UC1.AH57 UC1.AJ13 UC1.AJ14 UC1.AJ23 UC1.AJ25 UC1.AJ27 UC1.AJ29 UC1.AJ35 UC1.AJ39 UC1.AJ41 UC1.AJ43 UC1.AJ45 UC1.AJ47 UC1.AJ50 UC1.AJ52 UC1.AJ54 UC1.AJ56 UC1.AJ58 UC1.AJ60 UC1.AJ63 UC1.AK3 UC1.AK23 UC1.AK52 UC1.AL10 UC1.AL13 UC1.AL17 UC1.AL20 UC1.AL22 UC1.AL23 UC1.AL26 UC1.AL29 UC1.AL31 UC1.AL33 UC1.AL36 UC1.AL39 UC1.AL40 UC1.AL45 UC1.AL46 UC1.AL51 UC1.AL52 UC1.AL54 UC1.AL57 UC1.AL60 UC1.AL61 UC1.AM1 UC1.AM17 UC1.AM23 UC1.AM31 UC1.AM52 UC1.AN7 UC1.AN17 UC1.AN23 UC1.AN31 UC1.AN32 UC1.AN35 UC1.AN36 UC1.AN39 UC1.AN40 UC1.AN42 UC1.AN43 UC1.AN45 UC1.AN46 UC1.AN48 UC1.AN49 UC1.AN51 UC1.AN52 UC1.AN60 UC1.AN63 UC1.AP3 UC1.AP10 UC1.AP17 UC1.AP20 UC1.AP22 UC1.AP23 UC1.AP26 UC1.AP29 UC1.AP31 UC1.AP38 UC1.AP39 UC1.AP48 UC1.AP52 UC1.AP54 UC1.AP57 UC1.AR5 UC1.AR11 UC1.AR15 UC1.AR17 UC1.AR23 UC1.AR31 UC1.AR33 UC1.AR39 UC1.AR43 UC1.AR49 UC1.AR52 UC1.AT13 UC1.AT35 UC1.AT37 UC1.AT40 UC1.AT42 UC1.AT43 UC1.AT46 UC1.AT49 UC1.AT61 UC1.AT62 UC1.AT63 UC1.AU1 UC1.AU16 UC1.AU18 UC1.AU20 UC1.AU22 UC1.AU24 UC1.AU26 UC1.AU28 UC1.AU30 UC1.AU33 UC1.AU51 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AV8 UC1.AV14 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV28 UC1.AV33 UC1.AV34 UC1.AV36 UC1.AV39 UC1.AV41 UC1.AV43 UC1.AV46 UC1.AV49 UC1.AV51 UC1.AV55 UC1.AV59 UC1.AW4 UC1.AW16 UC1.AW24 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW40 UC1.AW42 UC1.AW44 UC1.AW47 UC1.AW50 UC1.AW51 UC1.AW59 UC1.AW60 UC1.AY4 UC1.AY6 UC1.AY11 UC1.AY16 UC1.AY18 UC1.AY22 UC1.AY24 UC1.AY26 UC1.AY30 UC1.AY33 UC1.AY51 UC1.AY53 UC1.AY57 UC1.AY59 UC1.B4 UC1.B20 UC1.B24 UC1.B26 UC1.B28 UC1.B32 UC1.B36 UC1.B40 UC1.B44 UC1.B48 UC1.B52 UC1.B56 UC1.B60 UC1.C11 UC1.C14 UC1.C18 UC1.C20 UC1.C25 UC1.C27 UC1.C38 UC1.C39 UC1.C57 UC1.D2 UC1.D5 UC1.D8 UC1.D12 UC1.D14 UC1.D18 UC1.D21 UC1.D23 UC1.D25 UC1.D26 UC1.D27 UC1.D29 UC1.D30 UC1.D31 UC1.D33 UC1.D34 UC1.D35 UC1.D37 UC1.D38 UC1.D39 UC1.D41 UC1.D42 UC1.D43 UC1.D45 UC1.D46 UC1.D47 UC1.D49 UC1.D50 UC1.D51 UC1.D53 UC1.D54 UC1.D55 UC1.D57 UC1.D59 UC1.D62 UC1.D63 UC1.E11 UC1.E17 UC1.F20 UC1.F26 UC1.F30 UC1.F34 UC1.F38 UC1.F42 UC1.F46 UC1.F50 UC1.F54 UC1.F58 UC1.F61 UC1.G3 UC1.G5 UC1.G6 UC1.G8 UC1.G18 UC1.G22 UC1.H13 UC1.H17 UC1.H57 UC1.J10 UC1.J22 UC1.J59 UC1.J63 UC1.K1 UC1.K12 UC1.L7 UC1.L13 UC1.L15 UC1.L17 UC1.L18 UC1.L20 UC1.L58 UC1.L61 UC1.M22 UC1.N3 UC1.N10 UC1.N21 UC1.P22 UC1.P59 UC1.P62 UC1.P63 UC1.R8 UC1.R10 UC1.R22 UC1.T1 UC1.T58 UC1.U9 UC1.U20 UC1.U22 UC1.U61 UC1.V3 UC1.V7 UC1.V10 UC1.V23 UC1.V58 UC1.W20 UC1.W22 UC1.Y10 UC1.Y59 UC1.Y63 UC3.3 UC4.7 UC4.15 UD1.3 UE1.11 UE1.24 UE1.35 UE1.94 UE1.113 UE2.3 UE3.5 UE3.6 UE3.7 UE3.8 UG1.4 UG1.7 UG1.13 UG1.17 UI2.1 UI2.9 UI3.1 UI3.9 UI4.1 UI4.9 UI5.1 UI5.9 UL1.33 UL2.2 UR1.25 UV1.A3 UV1.A37 UV1.AA2 UV1.AA6 UV1.AA16 UV1.AA18 UV1.AA21 UV1.AA23 UV1.AA26 UV1.AA28 UV1.AB12 UV1.AB15 UV1.AB17 UV1.AB20 UV1.AB22 UV1.AB24 UV1.AB27 UV1.AB39 UV1.AC2 UV1.AC6 UV1.AC11 UV1.AC13 UV1.AC16 UV1.AC18 UV1.AC21 UV1.AC23 UV1.AC26 UV1.AC28 UV1.AC34 UV1.AD9 UV1.AD15 UV1.AD17 UV1.AD20 UV1.AD22 UV1.AD24 UV1.AD27 UV1.AD35 UV1.AD37 UV1.AE2 UV1.AE6 UV1.AE34 UV1.AE38 UV1.AF10 UV1.AF16 UV1.AF18 UV1.AF21 UV1.AF39 UV1.AG2 UV1.AG6 UV1.AG9 UV1.AG17 UV1.AG20 UV1.AG22 UV1.AH21 UV1.AH39 UV1.AJ2 UV1.AJ6 UV1.AJ10 UV1.AJ11 UV1.AJ28 UV1.AJ33 UV1.AK7 UV1.AK11 UV1.AK31 UV1.AK39 UV1.AL2 UV1.AL6 UV1.AL8 UV1.AL11 UV1.AL14 UV1.AL17 UV1.AL20 UV1.AL23 UV1.AL26 UV1.AL32 UV1.AL34 UV1.AM9 UV1.AM11 UV1.AM31 UV1.AM35 UV1.AN2 UV1.AN6 UV1.AN8 UV1.AN10 UV1.AN11 UV1.AN17 UV1.AN19 UV1.AN27 UV1.AN29 UV1.AN30 UV1.AN34 UV1.AN38 UV1.AP7 UV1.AP9 UV1.AP11 UV1.AP16 UV1.AP17 UV1.AP18 UV1.AP19 UV1.AP27 UV1.AP28 UV1.AP29 UV1.AP30 UV1.AP39 UV1.AR5 UV1.AR18 UV1.AR28 UV1.AR39 UV1.AU37 UV1.AV17 UV1.AV27 UV1.AW14 UV1.AW16 UV1.AW20 UV1.AW22 UV1.AW24 UV1.AW26 UV1.AW30 UV1.AW32 UV1.AW34 UV1.AW35 UV1.B7 UV1.B9 UV1.B11 UV1.B13 UV1.B15 UV1.B17 UV1.B19 UV1.B21 UV1.B23 UV1.B25 UV1.B27 UV1.B29 UV1.B31 UV1.B33 UV1.C1 UV1.C39 UV1.E5 UV1.E35 UV1.E39 UV1.F7 UV1.F9 UV1.F11 UV1.F13 UV1.F15 UV1.F17 UV1.F19 UV1.F21 UV1.F23 UV1.F25 UV1.F27 UV1.F29 UV1.F31 UV1.F33 UV1.F34 UV1.F39 UV1.G2 UV1.G6 UV1.G33 UV1.G34 UV1.H9 UV1.H31 UV1.H34 UV1.H39 UV1.J2 UV1.J6 UV1.J8 UV1.J27 UV1.J31 UV1.J34 UV1.K7 UV1.K14 UV1.K31 UV1.K34 UV1.K39 UV1.L2 UV1.L6 UV1.L11 UV1.L17 UV1.L22 UV1.L24 UV1.L31 UV1.L34 UV1.M17 UV1.M22 UV1.M24 UV1.M34 UV1.M39 UV1.N2 UV1.N6 UV1.N16 UV1.N18 UV1.N21 UV1.N23 UV1.N26 UV1.N31 UV1.N34 UV1.P31 UV1.P34 UV1.P39 UV1.R2 UV1.R6 UV1.R15 UV1.R17 UV1.R20 UV1.R22 UV1.R24 UV1.R27 UV1.R34 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T23 UV1.T26 UV1.T31 UV1.T34 UV1.T39 UV1.U2 UV1.U6 UV1.U13 UV1.U15 UV1.U17 UV1.U20 UV1.U22 UV1.U24 UV1.U27 UV1.U31 UV1.U34 UV1.V11 UV1.V13 UV1.V16 UV1.V18 UV1.V21 UV1.V23 UV1.V26 UV1.V34 UV1.V39 UV1.W2 UV1.W6 UV1.W31 UV1.W34 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y22 UV1.Y24 UV1.Y27 UV1.Y34 UV1.Y39 UV3.A1 UV3.A3 UV3.A12 UV3.A14 UV3.B5 UV3.B10 UV3.C1 UV3.C3 UV3.C4 UV3.C11 UV3.C12 UV3.C13 UV3.C14 UV3.D10 UV3.E1 UV3.E3 UV3.E12 UV3.E14 UV3.F5 UV3.F10 UV3.G5 UV3.G10 UV3.H1 UV3.H2 UV3.H13 UV3.H14 UV3.J10 UV3.K1 UV3.K2 UV3.K13 UV3.K14 UV3.L5 UV3.L10 UV3.M5 UV3.M10 UV3.N1 UV3.N3 UV3.N12 UV3.N14 UV3.P10 UV3.R1 UV3.R3 UV3.R4 UV3.R11 UV3.R12 UV3.R14 UV3.T5 UV3.T10 UV3.U1 UV3.U3 UV3.U12 UV3.U14 UV4.A1 UV4.A3 UV4.A12 UV4.A14 UV4.B5 UV4.B10 UV4.C1 UV4.C3 UV4.C4 UV4.C11 UV4.C12 UV4.C13 UV4.C14 UV4.D10 UV4.E1 UV4.E3 UV4.E12 UV4.E14 UV4.F5 UV4.F10 UV4.G5 UV4.G10 UV4.H1 UV4.H2 UV4.H13 UV4.H14 UV4.J1 UV4.J10 UV4.K1 UV4.K2 UV4.K13 UV4.K14 UV4.L5 UV4.L10 UV4.M5 UV4.M10 UV4.N1 UV4.N3 UV4.N12 UV4.N14 UV4.P10 UV4.R1 UV4.R3 UV4.R4 UV4.R11 UV4.R12 UV4.R14 UV4.T5 UV4.T10 UV4.U1 UV4.U3 UV4.U12 UV4.U14 UV5.A1 UV5.A3 UV5.A12 UV5.A14 UV5.B5 UV5.B10 UV5.C1 UV5.C3 UV5.C4 UV5.C11 UV5.C12 UV5.C13 UV5.C14 UV5.D10 UV5.E1 UV5.E3 UV5.E12 UV5.E14 UV5.F5 UV5.F10 UV5.G5 UV5.G10 UV5.H1 UV5.H2 UV5.H13 UV5.H14 UV5.J10 UV5.K1 UV5.K2 UV5.K13 UV5.K14 UV5.L5 UV5.L10 UV5.M5 UV5.M10 UV5.N1 UV5.N3 UV5.N12 UV5.N14 UV5.P10 UV5.R1 UV5.R3 UV5.R4 UV5.R11 UV5.R12 UV5.R14 UV5.T5 UV5.T10 UV5.U1 UV5.U3 UV5.U12 UV5.U14 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C13 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.J1 UV6.J10 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV7.A1 UV7.A3 UV7.A12 UV7.A14 UV7.B5 UV7.B10 UV7.C1 UV7.C3 UV7.C4 UV7.C11 UV7.C12 UV7.C13 UV7.C14 UV7.D10 UV7.E1 UV7.E3 UV7.E12 UV7.E14 UV7.F5 UV7.F10 UV7.G5 UV7.G10 UV7.H1 UV7.H2 UV7.H13 UV7.H14 UV7.J10 UV7.K1 UV7.K2 UV7.K13 UV7.K14 UV7.L5 UV7.L10 UV7.M5 UV7.M10 UV7.N1 UV7.N3 UV7.N12 UV7.N14 UV7.P10 UV7.R1 UV7.R3 UV7.R4 UV7.R11 UV7.R12 UV7.R14 UV7.T5 UV7.T10 UV7.U1 UV7.U3 UV7.U12 UV7.U14 UV8.A1 UV8.A3 UV8.A12 UV8.A14 UV8.B5 UV8.B10 UV8.C1 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.C13 UV8.C14 UV8.D10 UV8.E1 UV8.E3 UV8.E12 UV8.E14 UV8.F5 UV8.F10 UV8.G5 UV8.G10 UV8.H1 UV8.H2 UV8.H13 UV8.H14 UV8.J1 UV8.J10 UV8.K1 UV8.K2 UV8.K13 UV8.K14 UV8.L5 UV8.L10 UV8.M5 UV8.M10 UV8.N1 UV8.N3 UV8.N12 UV8.N14 UV8.P10 UV8.R1 UV8.R3 UV8.R4 UV8.R11 UV8.R12 UV8.R14 UV8.T5 UV8.T10 UV8.U1 UV8.U3 UV8.U12 UV8.U14 UV9.A1 UV9.A3 UV9.A12 UV9.A14 UV9.B5 UV9.B10 UV9.C1 UV9.C3 UV9.C4 UV9.C11 UV9.C12 UV9.C13 UV9.C14 UV9.D10 UV9.E1 UV9.E3 UV9.E12 UV9.E14 UV9.F5 UV9.F10 UV9.G5 UV9.G10 UV9.H1 UV9.H2 UV9.H13 UV9.H14 UV9.J10 UV9.K1 UV9.K2 UV9.K13 UV9.K14 UV9.L5 UV9.L10 UV9.M5 UV9.M10 UV9.N1 UV9.N3 UV9.N12 UV9.N14 UV9.P10 UV9.R1 UV9.R3 UV9.R4 UV9.R11 UV9.R12 UV9.R14 UV9.T5 UV9.T10 UV9.U1 UV9.U3 UV9.U12 UV9.U14 UV10.A1 UV10.A3 UV10.A12 UV10.A14 UV10.B5 UV10.B10 UV10.C1 UV10.C3 UV10.C4 UV10.C11 UV10.C12 UV10.C13 UV10.C14 UV10.D10 UV10.E1 UV10.E3 UV10.E12 UV10.E14 UV10.F5 UV10.F10 UV10.G5 UV10.G10 UV10.H1 UV10.H2 UV10.H13 UV10.H14 UV10.J1 UV10.J10 UV10.K1 UV10.K2 UV10.K13 UV10.K14 UV10.L5 UV10.L10 UV10.M5 UV10.M10 UV10.N1 UV10.N3 UV10.N12 UV10.N14 UV10.P10 UV10.R1 UV10.R3 UV10.R4 UV10.R11 UV10.R12 UV10.R14 UV10.T5 UV10.T10 UV10.U1 UV10.U3 UV10.U12 UV10.U14 UV13.3 UV14.5 UX1.2 UX2.3 UX4.6 UX4.16 UX4.49 X1.2 X1.4 YG1.2 YG1.4 YL2.2 YL2.4 YV1.2 YV1.4
GNDA: CA1.2 CA2.2 CA23.1 CA33.2 CA38.2 CA39.2 CA40.2 CA51.2 CA61.2 CA62.1 CA63.1 CA71.2 JHP.6 JHP.7 QA5.1 QA5.4 QA6.1 QA6.4 RA29.1 RA30.1 RA31.1 RA32.1 RA83.2 RA84.2 RA153.1 UA1.25 UA1.38
V5A_CPU: PC505.1 PR519.2 PU501.28
V18: CR4.2 UR1.24
VBAT_CPU: PR508.2 PU501.16
VCC: PC710.1 PR705.2 PU701.20
VCCSENSE: PU501.24 R1.2 UC1.E63
VCCSENSE_VGA: PR846.2 RV202.2 UV1.AF28
VCCST_PG_EC: C95.1 CE35.1 DE1.2 R286.2 UC1.B59 UE1.123
VDD_1.35V: PC209.1 PR205.1 PR206.2 PU200.11
VDDCI_SEN: PR1210.2 RV215.2 UV1.AG28
VIN: PC3.1 PC4.1 PC701.1 PL1.2 PQ701.1 PR5.1 PR7.2 PR31.2 PR705.1 PR720.1 PR723.2
VSSSENSE: PU501.23 R2.1 RC163.1 UC1.E62
VSSSENSE_VGA: PR845.2 RV204.1 UV1.AH29
65W#/90W: PQ4.2 UE1.117
6511_PWR_EN: PR1003.1 Q4.2 U4.43
6511_PWR_EN#: C411.1 Q3.2 Q4.1 Q25.2 R38.1
62881_COMP: PC806.2 PC814.2 PC818.2 PR817.2 PU800.5
62881_FB: PC814.1 PR813.1 PR818.1 PR821.1 PU800.6
62881_RBIAS: PR815.1 PU800.3
62881_VCCP: PC803.1 PR814.1 PU800.19
62881_VDD: PC811.1 PR822.1 PU800.11
62881_VID0: PR811.2 PU800.20
62881_VID1: PR810.2 PU800.21
62881_VID2: PR812.2 PU800.22
62881_VID3: PR807.2 PU800.23
62881_VID4: PR809.2 PU800.24
62881_VID5: PR806.2 PU800.25
62881_VID6: PR804.2 PU800.26
62881_VIN: PC810.1 PR823.1 PU800.12
62881_VR_ON: PC869.1 PR803.2 PU800.27
62881_VW: PC818.1 PR817.1 PU800.4
+BIF_VDDC: CV97.1 CV195.1 CV196.1 RV103.2 RV234.1 RV245.2 UV1.N27 UV1.T27
+CHGRTC: DC1.3 JP12.2
+CODEC_AVDD2: CA61.1 RA8.2 RA9.2 UA1.40
+CPU_CORE: C40.1 CM45.2 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PL502.4 R1.1 UC1.AB57 UC1.AD57 UC1.AG57 UC1.C24 UC1.C28 UC1.C32 UC1.C36 UC1.C40 UC1.C44 UC1.C48 UC1.C52 UC1.C56 UC1.E23 UC1.E25 UC1.E27 UC1.E29 UC1.E31 UC1.E33 UC1.E35 UC1.E37 UC1.E39 UC1.E41 UC1.E43 UC1.E45 UC1.E47 UC1.E49 UC1.E51 UC1.E53 UC1.E55 UC1.E57 UC1.F24 UC1.F28 UC1.F32 UC1.F36 UC1.F40 UC1.F44 UC1.F48 UC1.F52 UC1.F56 UC1.F59 UC1.G23 UC1.G25 UC1.G27 UC1.G29 UC1.G31 UC1.G33 UC1.G35 UC1.G37 UC1.G39 UC1.G41 UC1.G43 UC1.G45 UC1.G47 UC1.G49 UC1.G51 UC1.G53 UC1.G55 UC1.G57 UC1.H23 UC1.J23 UC1.K23 UC1.K57 UC1.L22 UC1.M23 UC1.M57 UC1.P57 UC1.U57 UC1.W57
+CRT_VCC: C1.1 CRTF1.2 JCRT1.9 RE4.1
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2
+DIMM2_VREF_DQ: CD32.1 CD33.1 JDIMM2.1 RD8.2
+DPAB_VDD10: CV114.1 CV115.1 CV116.1 RV120.1 UV1.AN33 UV1.AP31 UV1.AP32 UV1.AP33
+DPAB_VDD18: CV108.1 CV109.1 CV110.1 RV118.1 UV1.AN24 UV1.AP24 UV1.AP25 UV1.AP26 UV1.AU28 UV1.AV29
+DPCD_VDD10: CV117.1 CV118.1 CV119.1 RV121.2 UV1.AP13 UV1.AP14 UV1.AP15 UV1.AT13
+DPCD_VDD18: CV111.1 CV112.1 CV113.1 RV119.2 UV1.AP20 UV1.AP21 UV1.AP22 UV1.AP23 UV1.AU18 UV1.AV19
+DPEF_VDD10: CV123.1 CV124.1 CV125.1 RV126.2 UV1.AK33 UV1.AK34 UV1.AL33 UV1.AM33
+DPEF_VDD18: CV120.1 CV121.1 CV122.1 RV124.2 UV1.AF34 UV1.AG34 UV1.AH34 UV1.AJ34 UV1.AL38 UV1.AM37
+DPLL_PVDD: CV82.1 CV83.1 CV84.1 LV14.1 RV246.2 UV1.AM32
+DPLL_VDDC: CV86.1 CV87.1 CV88.1 LV15.1 UV1.AN31
+EC_VCCA: CE7.1 LE1.2 PR24.2 UE1.67
+FAN_POWER: CE22.1 CE23.1 JFAN.1 UE3.3
+INV_PWR_SRC: CX5.1 JLVDS.39 JLVDS.40 QX2.1 QX2.2 QX2.5 QX2.6
+LAN_IO: CG3.1 CL15.1 CL19.1 CL43.1 CL44.1 JP3.1 RL34.1 RL38.2 UG1.8 UL1.11 UL1.23 UL1.32 UL2.1
+LAN_VDD: CL20.1 CL22.1 CL26.1 CL34.1 CL35.1 CL42.1 UL1.3 UL1.8 UL1.22 UL1.24 UL1.30
+LCDVDD: CX2.1 CX3.1 LX1.1 UX1.1
+LCDVDD_CONN: CX8.1 CX11.1 JLVDS.24 JLVDS.25 LX1.2
+MIC2-VREFO: RA53.2 RA1109.2 UA1.29
+MPV18: CV197.1 CV198.1 CV199.1 LV21.2 UV1.H7 UV1.H8
+PCH_VCCDSW: R265.1 UC1.AG19 UC1.AG20
+PCH_VCCDSW_R: C64.1 R265.2
+PCIE_PVDD: CV132.1 CV133.1 CV134.1 LV18.2 UV1.AB37
+PCIE_VDDR: CV126.1 CV127.1 CV128.1 CV129.1 CV130.1 CV131.1 LV17.2 RV244.2 UV1.AA31 UV1.AA32 UV1.AA33 UV1.AA34 UV1.W30 UV1.Y31
+RTCBATT: JRTC.1 RC10.2 RG1.1
+RTCVCC: C54.1 C55.1 C56.1 CC26.1 DC1.1 R2337.2 RA5.1 RC1.1 RC5.1 RC6.1 RC7.1 RG2.1 UC1.AG10
+SM_VREF_CA: CC8.1 RC17.2 UC1.AP49
+SM_VREF_CA_DIMM: RC14.2 RC17.1 RC20.1 RD4.2 RD10.2
+SM_VREF_DQ0: CC10.1 RC19.2 UC1.AR51
+SM_VREF_DQ0_DIMM1: RC16.2 RC19.1 RC22.1 RD1.1
+SM_VREF_DQ1: CC9.1 RC18.2 UC1.AP51
+SM_VREF_DQ1_DIMM2: RC15.2 RC18.1 RC21.1 RD8.1
+SPV10: CV215.1 CV216.1 CV217.1 LV23.2 UV1.AN9
+SPV18: CV200.1 CV201.1 CV202.1 LV22.2 UV1.AM10
+SW_LX: LX9.2 UX4.17
+SWR_V12: CX32.1 CX37.1 CX47.1 CX48.1 LX9.1 UX4.11 UX4.15 UX4.43
+TSVDD: CV91.1 CV92.1 CV93.1 LV16.2 UV1.AJ32
+V_DAC: CL41.2 TL2.3 TL2.4 TL2.9 TL2.10
+VCHGR: PC712.1 PC713.1 PC716.1 PQ702.1 PQ702.2 PQ702.3 PR716.4
+VGA_CORE: CV327.1 LV25.2 LV26.2 PC835.1 PC836.1 PC837.1 PC838.1 PC839.1 PC840.1 PC841.1 PC842.1 PC843.1 PC844.1 PC845.1 PC846.1 PC847.1 PC848.1 PC849.1 PC850.1 PC851.1 PC852.1 PC853.1 PC854.1 PC855.1 PC856.1 PC857.1 PC858.1 PC859.1 PC860.1 PC861.1 PC862.1 PC863.1 PC864.1 PC865.1 PC866.1 PC867.1 PC868.1 PC870.1 PC871.1 PC872.1 PC873.1 PL802.2 PR820.2 PR830.1 RV202.1 RV234.2 UV1.AA15 UV1.AA17 UV1.AA20 UV1.AA22 UV1.AA24 UV1.AA27 UV1.AB16 UV1.AB18 UV1.AB21 UV1.AB23 UV1.AB26 UV1.AB28 UV1.AC17 UV1.AC20 UV1.AC22 UV1.AC24 UV1.AC27 UV1.AD18 UV1.AD21 UV1.AD23 UV1.AD26 UV1.AF17 UV1.AF20 UV1.AF22 UV1.AG16 UV1.AG18 UV1.AG21 UV1.AH22 UV1.AH27 UV1.AH28 UV1.M26 UV1.N24 UV1.R18 UV1.R21 UV1.R23 UV1.R26 UV1.T17 UV1.T20 UV1.T22 UV1.T24 UV1.U16 UV1.U18 UV1.U21 UV1.U23 UV1.U26 UV1.V17 UV1.V20 UV1.V22 UV1.V24 UV1.V27 UV1.Y16 UV1.Y18 UV1.Y21 UV1.Y23 UV1.Y26 UV1.Y28
+VGA_PCIE: CV146.1 CV147.1 CV148.1 CV149.1 CV150.1 CV151.1 LV15.2 LV23.1 PJP1300.1 RV103.1 RV120.2 RV121.1 RV126.1 RV198.2 RV203.2 UV1.G30 UV1.G31 UV1.H29 UV1.H30 UV1.J29 UV1.J30 UV1.L28 UV1.M28 UV1.N28 UV1.R28 UV1.T28 UV1.U28
+VGA_PCIEP: PC1300.1 PC1303.1 PC1305.1 PC1306.1 PC1308.1 PJP1300.2 PL1300.2 PR1302.1
+VREFG_GPU: CV81.1 RV93.1 RV95.1 UV1.AH13
/BATDRV: PR706.2 PU701.11
AC_BATT: QV14.3 RV73.2 RV85.2 UV1.AH17
AC_PRESENT: DH1.2 RC32.2 UC1.AJ8
ACDET: PC711.2 PR711.2 PR723.1 PU701.6
ACDRV: PR703.2 PU701.4
ACIN: CE18.2 DH1.1 PR1.1 PR707.2 PR712.1 PU701.5 RV250.1 UE1.110
ACIN_65W: QV14.2 RV250.2 UE1.108
ACOFF: PQ706.2 UE1.27
AD_BID0: CE8.1 RE3.1 RE5.2 UE1.75
ADBIA0: UV1.J21 UV4.J4 UV5.J4
ADBIA1: UV1.G19 UV3.J4 UV6.J4
ADBIB0: UV1.T7 UV7.J4 UV8.J4
ADBIB1: UV1.W7 UV9.J4 UV10.J4
ADP_I: PC720.2 PR23.2 PU701.7 UE1.65
ADPIN: PC1.1 PC2.1 PJPDC.4 PJPDC.5 PL1.1
AUD_HP_OUT_L_CN: CA39.1 DA10.3 JHP.1 LA8.1
AUD_HP_OUT_R_CN: CA33.1 DA10.2 JHP.2 LA9.1
B+: CX4.1 PC714.1 PC718.1 PL102.1 PL201.1 PL302.1 PL501.2 PL701.2 PL800.1 PL1100.2 PL1201.1 PR716.1 QX2.4 RS6.2 RX2.1
B+_1.05V: PC303.1 PC304.1 PC305.1 PC306.1 PL302.2 PU300.8
B+_VDDCI: PC1202.1 PC1203.1 PC1204.1 PC1209.1 PL1201.2 PU1200.8
B-RAMP: PR507.1 PR509.2 PU501.11
BAT_ALERT: PBATT.3 PD1.4 PD2.2
BATT+: PC7.1 PL3.1 PQ702.5 PQ702.6 PQ702.7 PQ702.8
BATT++: PBATT.8 PBATT.9 PC8.1 PL3.2
BATT_CHG_LED#: RD16.1 UE1.90
BATT_LOW_LED#: RD17.1 UE1.93
BATT_PRS: PBATT.5 PC14.1 PR15.1 PR17.2
BATT_TEMP: CE9.2 PC723.2 PR15.2 PR16.1 UE1.63
BBS_BIT: RC119.2 RC123.1 UC1.L8
BEEP#: DA8.2 UE1.23
BKOFF#: RX50.1 UE1.105 UX2.1
BLUE_CRT: C4.1 L9.1 R34.1 U4.12
BLUE_CRT_L: C7.1 DE4.2 JCRT1.3 L9.2
BOOT_1.35V: PR200.2 PU200.18
BST: PR709.1 PU701.17
BST_1.05V: PR303.1 PU300.6
BST_1.35V: PC200.1 PR200.1
BST_3V: PR103.2 PU100.9
BST_5V: PR111.1 PU100.17
BST_+1.2VSP: PR1101.1 PU1100.10
BST_CHGA: PC721.1 PD701.1 PR709.2
BST_VDDCI: PR1200.1 PU1200.6
BST_VGA_CORE: PR802.1 PU800.14
BT_LED#: JMINI.46 QD19.3 RD47.2 RD49.1 UD1.2
BT_ON#: RM13.2 RP54.2 UC1.AD5
CAPS_LED: JKB.1 UE1.91
CASA0#: UV1.K20 UV4.L3 UV5.G3
CASA1#: UV1.K17 UV3.G3 UV6.L3
CASB0#: UV1.W10 UV7.G3 UV8.L3
CASB1#: UV1.AA10 UV9.G3 UV10.L3
CE_EN: RX18.1 UE1.17
CE_EN_R: JLVDS.18 RX18.2 RX20.1 RX53.2
CFD_PWRBTN#_XDP: JXDP1.41 RC49.2
CFG0: JXDP1.9 UC1.AC60
CFG1: JXDP1.11 UC1.AC62
CFG2: JXDP1.15 UC1.AC63
CFG3: JXDP1.17 RC56.2 UC1.AA63
CFG3_R: JXDP1.60 RC56.1
CFG4: JXDP1.27 RC138.1 UC1.AA60
CFG5: JXDP1.29 UC1.Y62
CFG6: JXDP1.33 UC1.Y61
CFG7: JXDP1.35 UC1.Y60
CFG8: JXDP1.10 UC1.V62
CFG9: JXDP1.12 UC1.V61
CFG10: JXDP1.16 UC1.V60
CFG11: JXDP1.18 UC1.U60
CFG12: JXDP1.28 UC1.T63
CFG13: JXDP1.30 UC1.T62
CFG14: JXDP1.34 UC1.T61
CFG15: JXDP1.36 UC1.T60
CFG16: JXDP1.6 UC1.AA62
CFG17: JXDP1.4 UC1.AA61
CFG18: JXDP1.24 UC1.U63
CFG19: JXDP1.22 UC1.U62
CFG_RCOMP: RC132.1 UC1.V63
CHG_B+: PC703.1 PC704.1 PC705.1 PC706.1 PC724.1 PL702.2 PQ703.5 PQ704.5
CKEA0: UV1.K21 UV4.J3 UV5.J3
CKEA1: UV1.J20 UV3.J3 UV6.J3
CKEB0: UV1.U10 UV7.J3 UV8.J3
CKEB1: UV1.AA11 UV9.J3 UV10.J3
CLK_BIASREF: RC13.1 UC1.C26
CLK_CPU_ITP: RC139.2 UC1.A35
CLK_CPU_ITP#: RC140.2 UC1.B35
CLK_PCI_LPC: R2336.1 R2354.2 UE1.12
CLK_PCIE_LAN: UC1.B42 UL1.15
CLK_PCIE_LAN#: UC1.C41 UL1.16
CLK_PCIE_WLAN: JMINI.13 UC1.C37
CLK_PCIE_WLAN#: JMINI.11 UC1.B38
CLK_PEG_VGA: UC1.B39 UV1.AB35
CLK_PEG_VGA#: UC1.A39 UV1.AA36
CLK_SMB: PBATT.7 PD1.3 PD3.3 PR18.1
CLK_X1: CG8.1 UG1.1 YG1.1
CLK_X2: CG9.1 UG1.16 YG1.3
CLK_XDP: JXDP1.40 RC139.1
CLK_XDP#: JXDP1.42 RC140.1
CLKA0: RV42.2 UV1.H27 UV4.J12 UV5.J12
CLKA0#: RV43.2 UV1.G27 UV4.J11 UV5.J11
CLKA1: RV44.2 UV1.J14 UV3.J12 UV6.J12
CLKA1#: RV45.2 UV1.H14 UV3.J11 UV6.J11
CLKB0: RV46.2 UV1.L9 UV7.J12 UV8.J12
CLKB0#: RV47.2 UV1.L8 UV7.J11 UV8.J11
CLKB1: RV48.2 UV1.AD8 UV9.J12 UV10.J12
CLKB1#: RV49.2 UV1.AD7 UV9.J11 UV10.J11
CLKOUT_LPC0: R2336.2 UC1.AN15
CLKRUN#: RC36.2 UC1.V5
CMSRC: PR721.1 PU701.3
CODEC_IRQ: RC88.1 UC1.L4
COMP_CPU: PC513.1 PC514.2 PR531.2 PR532.2 PU501.26
CPPE#: RC108.2 UC1.J1
CPU_DETECT#: CE33.1 RE11.1 UC1.D61 UE1.127
CPU_DPB_AUX: C94.2 R24.1 RP51.2 U4.22 UC1.B5
CPU_DPB_AUX#: C47.2 R25.1 RP51.1 U4.21 UC1.C5
CPU_DPB_AUX#_C: C47.1 U4.23
CPU_DPB_AUX_C: C94.1 U4.24
CPU_DPB_CTRLCLK: RP52.2 UC1.B9
CPU_DPB_CTRLDAT: RP52.1 UC1.C9
CPU_DPC_AUX: RP51.4 UC1.A6
CPU_DPC_AUX#: RP51.3 UC1.B6
CPU_DPC_CTRLCLK: RP52.3 UC1.D9
CPU_DPC_CTRLDAT: RP52.4 UC1.D11
CPU_EDP_AUX#_C: CX44.2 RX37.1 UX4.3
CPU_EDP_AUX_C: CX43.2 RX39.1 UX4.4
CPU_EDP_HPD#: QC3.1 RC78.2 RC89.1 RC105.2 UC1.D6
CPU_EDP_N0_C: CX46.2 RX43.1 UX4.8
CPU_EDP_N1_C: CX39.2 RX47.1 UX4.10
CPU_EDP_P0_C: CX42.2 RX41.1 UX4.7
CPU_EDP_P1_C: CX38.2 RX45.1 UX4.9
CPU_PWR_DEBUG#: R253.1 R255.2 RC50.1 UC1.H59
CPU_PWR_DEBUG#_R: JXDP1.45 RC50.2
CPUSB#: RC111.2 UC1.K3
CRT_CLK: C13.1 JCRT1.15 Q2.3 R27.2
CRT_CLK_1: Q2.4 R22.2 R42.2 RP1.6
CRT_DATA: C12.1 JCRT1.12 Q2.6 R28.2
CRT_DATA_1: Q2.1 R21.2 R40.2 RP1.5
CRT_HSYNC: R13.2 U1.2
CRT_HSYNC_2: C10.1 DE5.3 JCRT1.13 R3.2
CRT_VSYNC: R6.2 U2.2
CRT_VSYNC_2: C11.1 DE5.2 JCRT1.14 R4.2
CS1: PR105.1 PU100.1
CS2: PR108.1 PU100.5
CS_1.35V: PR205.2 PU200.13
CSA0#_0: UV1.K24 UV4.G12 UV5.L12
CSA1#_0: UV1.M13 UV3.L12 UV6.G12
CSB0#_0: UV1.P10 UV7.L12 UV8.G12
CSB1#_0: UV1.AD10 UV9.L12 UV10.G12
CSCL: QX6.4 RP57.2 RX6.2 UX4.13
CSDA: QX6.1 RP57.1 RX31.2 UX4.14
CSIN: PR702.3 PR704.2
CSIP: PR702.2 PR717.2
CSN1_CPU: PC510.1 PC511.1 PL502.3 PR515.2 PR517.2 PU501.18
CSP1_CPU: PC510.2 PC511.2 PH501.1 PR517.1 PR518.1 PU501.17
DAT_SMB: PBATT.6 PD1.1 PD3.2 PR20.1
DBC_EN: RX19.1 UE1.25
DBC_EN_R: JLVDS.21 RX19.2 RX23.1
DC_TEST_A3_B3: UC1.A3 UC1.B3
DC_TEST_A4: T168.1(TP-1) UC1.A4
DC_TEST_A60: T169.1(TP-1) UC1.A60
DC_TEST_A61_B61: UC1.A61 UC1.B61
DC_TEST_A62: T170.1(TP-1) UC1.A62
DC_TEST_AV1: T171.1(TP-1) UC1.AV1
DC_TEST_AW1: T172.1(TP-1) UC1.AW1
DC_TEST_AW63: T173.1(TP-1) UC1.AW63
DC_TEST_AY2_AW2: UC1.AW2 UC1.AY2
DC_TEST_AY3_AW3: UC1.AW3 UC1.AY3
DC_TEST_AY60: T166.1(TP-1) UC1.AY60
DC_TEST_AY61_AW61: UC1.AW61 UC1.AY61
DC_TEST_AY62_AW62: UC1.AW62 UC1.AY62
DC_TEST_B62_B63: UC1.B62 UC1.B63
DC_TEST_C1_C2: UC1.C1 UC1.C2
DDBIA0_0: UV1.A34 UV5.P13
DDBIA0_1: UV1.E30 UV4.D2
DDBIA0_2: UV1.E26 UV5.D2
DDBIA0_3: UV1.C20 UV4.P13
DDBIA1_0: UV1.C16 UV3.P13
DDBIA1_1: UV1.C12 UV6.D2
DDBIA1_2: UV1.J11 UV3.D2
DDBIA1_3: UV1.F8 UV6.P13
DDBIB0_0: UV1.G7 UV7.P13
DDBIB0_1: UV1.K1 UV8.D2
DDBIB0_2: UV1.P1 UV8.P13
DDBIB0_3: UV1.W4 UV7.D2
DDBIB1_0: UV1.AC4 UV10.D2
DDBIB1_1: UV1.AH3 UV9.P13
DDBIB1_2: UV1.AJ8 UV9.D2
DDBIB1_3: UV1.AM3 UV10.P13
DDCSCL: R18.2 R20.2 U4.55
DDCSDA: R37.2 R41.2 U4.56
DDI1_LANE_N0: C33.2 UC1.C54
DDI1_LANE_N0_C: C33.1 U4.31
DDI1_LANE_N1: C49.2 UC1.B58
DDI1_LANE_N1_C: C49.1 U4.34
DDI1_LANE_P0: C32.2 UC1.C55
DDI1_LANE_P0_C: C32.1 U4.30
DDI1_LANE_P1: C34.2 UC1.C58
DDI1_LANE_P1_C: C34.1 U4.33
DDR3_DRAMRST#: CD3.1 CD34.1 JDIMM1.30 JDIMM2.30 RD5.1
DDR3_DRAMRST#_CPU: CC35.1 RD3.2 RD5.2 UC1.AV15
DDR_A_BS0: JDIMM1.109 UC1.AU35
DDR_A_BS1: JDIMM1.108 UC1.AV35
DDR_A_BS2: JDIMM1.79 UC1.AY41
DDR_A_CAS#: JDIMM1.115 UC1.AU34
DDR_A_D0: JDIMM1.129 UC1.AH63
DDR_A_D1: JDIMM1.131 UC1.AH62
DDR_A_D2: JDIMM1.141 UC1.AK63
DDR_A_D3: JDIMM1.140 UC1.AK62
DDR_A_D4: JDIMM1.132 UC1.AH61
DDR_A_D5: JDIMM1.130 UC1.AH60
DDR_A_D6: JDIMM1.143 UC1.AK61
DDR_A_D7: JDIMM1.142 UC1.AK60
DDR_A_D8: JDIMM1.7 UC1.AM63
DDR_A_D9: JDIMM1.4 UC1.AM62
DDR_A_D10: JDIMM1.17 UC1.AP63
DDR_A_D11: JDIMM1.18 UC1.AP62
DDR_A_D12: JDIMM1.6 UC1.AM61
DDR_A_D13: JDIMM1.5 UC1.AM60
DDR_A_D14: JDIMM1.15 UC1.AP61
DDR_A_D15: JDIMM1.16 UC1.AP60
DDR_A_D16: JDIMM1.159 UC1.AP58
DDR_A_D17: JDIMM1.157 UC1.AR58
DDR_A_D18: JDIMM1.146 UC1.AM57
DDR_A_D19: JDIMM1.148 UC1.AK57
DDR_A_D20: JDIMM1.149 UC1.AL58
DDR_A_D21: JDIMM1.147 UC1.AK58
DDR_A_D22: JDIMM1.158 UC1.AR57
DDR_A_D23: JDIMM1.160 UC1.AN57
DDR_A_D24: JDIMM1.24 UC1.AP55
DDR_A_D25: JDIMM1.22 UC1.AR55
DDR_A_D26: JDIMM1.36 UC1.AM54
DDR_A_D27: JDIMM1.34 UC1.AK54
DDR_A_D28: JDIMM1.23 UC1.AL55
DDR_A_D29: JDIMM1.21 UC1.AK55
DDR_A_D30: JDIMM1.33 UC1.AR54
DDR_A_D31: JDIMM1.35 UC1.AN54
DDR_A_D32: JDIMM1.166 UC1.AY58
DDR_A_D33: JDIMM1.165 UC1.AW58
DDR_A_D34: JDIMM1.175 UC1.AY56
DDR_A_D35: JDIMM1.174 UC1.AW56
DDR_A_D36: JDIMM1.163 UC1.AV58
DDR_A_D37: JDIMM1.164 UC1.AU58
DDR_A_D38: JDIMM1.177 UC1.AV56
DDR_A_D39: JDIMM1.176 UC1.AU56
DDR_A_D40: JDIMM1.42 UC1.AY54
DDR_A_D41: JDIMM1.41 UC1.AW54
DDR_A_D42: JDIMM1.50 UC1.AY52
DDR_A_D43: JDIMM1.51 UC1.AW52
DDR_A_D44: JDIMM1.39 UC1.AV54
DDR_A_D45: JDIMM1.40 UC1.AU54
DDR_A_D46: JDIMM1.52 UC1.AV52
DDR_A_D47: JDIMM1.53 UC1.AU52
DDR_A_D48: JDIMM1.69 UC1.AK40
DDR_A_D49: JDIMM1.67 UC1.AK42
DDR_A_D50: JDIMM1.59 UC1.AM43
DDR_A_D51: JDIMM1.57 UC1.AM45
DDR_A_D52: JDIMM1.56 UC1.AK45
DDR_A_D53: JDIMM1.58 UC1.AK43
DDR_A_D54: JDIMM1.68 UC1.AM40
DDR_A_D55: JDIMM1.70 UC1.AM42
DDR_A_D56: JDIMM1.192 UC1.AM46
DDR_A_D57: JDIMM1.194 UC1.AK46
DDR_A_D58: JDIMM1.183 UC1.AM49
DDR_A_D59: JDIMM1.182 UC1.AK49
DDR_A_D60: JDIMM1.191 UC1.AM48
DDR_A_D61: JDIMM1.193 UC1.AK48
DDR_A_D62: JDIMM1.181 UC1.AM51
DDR_A_D63: JDIMM1.180 UC1.AK51
DDR_A_DQS0: JDIMM1.137 UC1.AJ62
DDR_A_DQS1: JDIMM1.12 UC1.AN61
DDR_A_DQS2: JDIMM1.154 UC1.AN58
DDR_A_DQS3: JDIMM1.29 UC1.AN55
DDR_A_DQS4: JDIMM1.171 UC1.AW57
DDR_A_DQS5: JDIMM1.47 UC1.AW53
DDR_A_DQS6: JDIMM1.64 UC1.AL42
DDR_A_DQS7: JDIMM1.188 UC1.AL49
DDR_A_DQS#0: JDIMM1.135 UC1.AJ61
DDR_A_DQS#1: JDIMM1.10 UC1.AN62
DDR_A_DQS#2: JDIMM1.152 UC1.AM58
DDR_A_DQS#3: JDIMM1.27 UC1.AM55
DDR_A_DQS#4: JDIMM1.169 UC1.AV57
DDR_A_DQS#5: JDIMM1.45 UC1.AV53
DDR_A_DQS#6: JDIMM1.62 UC1.AL43
DDR_A_DQS#7: JDIMM1.186 UC1.AL48
DDR_A_MA0: JDIMM1.98 UC1.AU36
DDR_A_MA1: JDIMM1.97 UC1.AY37
DDR_A_MA2: JDIMM1.96 UC1.AR38
DDR_A_MA3: JDIMM1.95 UC1.AP36
DDR_A_MA4: JDIMM1.92 UC1.AU39
DDR_A_MA5: JDIMM1.91 UC1.AR36
DDR_A_MA6: JDIMM1.90 UC1.AV40
DDR_A_MA7: JDIMM1.86 UC1.AW39
DDR_A_MA8: JDIMM1.89 UC1.AY39
DDR_A_MA9: JDIMM1.85 UC1.AU40
DDR_A_MA10: JDIMM1.107 UC1.AP35
DDR_A_MA11: JDIMM1.84 UC1.AW41
DDR_A_MA12: JDIMM1.83 UC1.AU41
DDR_A_MA13: JDIMM1.119 UC1.AR35
DDR_A_MA14: JDIMM1.80 UC1.AV42
DDR_A_MA15: JDIMM1.78 UC1.AU42
DDR_A_RAS#: JDIMM1.110 UC1.AY34
DDR_A_WE#: JDIMM1.113 UC1.AW34
DDR_B_BS0: JDIMM2.109 UC1.AL35
DDR_B_BS1: JDIMM2.108 UC1.AM36
DDR_B_BS2: JDIMM2.79 UC1.AU49
DDR_B_CAS#: JDIMM2.115 UC1.AM33
DDR_B_D0: JDIMM2.132 UC1.AY31
DDR_B_D1: JDIMM2.131 UC1.AW31
DDR_B_D2: JDIMM2.140 UC1.AY29
DDR_B_D3: JDIMM2.141 UC1.AW29
DDR_B_D4: JDIMM2.129 UC1.AV31
DDR_B_D5: JDIMM2.130 UC1.AU31
DDR_B_D6: JDIMM2.142 UC1.AV29
DDR_B_D7: JDIMM2.143 UC1.AU29
DDR_B_D8: JDIMM2.5 UC1.AY27
DDR_B_D9: JDIMM2.6 UC1.AW27
DDR_B_D10: JDIMM2.15 UC1.AY25
DDR_B_D11: JDIMM2.17 UC1.AW25
DDR_B_D12: JDIMM2.4 UC1.AV27
DDR_B_D13: JDIMM2.16 UC1.AU27
DDR_B_D14: JDIMM2.7 UC1.AV25
DDR_B_D15: JDIMM2.18 UC1.AU25
DDR_B_D16: JDIMM2.146 UC1.AM29
DDR_B_D17: JDIMM2.148 UC1.AK29
DDR_B_D18: JDIMM2.160 UC1.AL28
DDR_B_D19: JDIMM2.158 UC1.AK28
DDR_B_D20: JDIMM2.149 UC1.AR29
DDR_B_D21: JDIMM2.147 UC1.AN29
DDR_B_D22: JDIMM2.157 UC1.AR28
DDR_B_D23: JDIMM2.159 UC1.AP28
DDR_B_D24: JDIMM2.24 UC1.AN26
DDR_B_D25: JDIMM2.22 UC1.AR26
DDR_B_D26: JDIMM2.33 UC1.AR25
DDR_B_D27: JDIMM2.35 UC1.AP25
DDR_B_D28: JDIMM2.21 UC1.AK26
DDR_B_D29: JDIMM2.23 UC1.AM26
DDR_B_D30: JDIMM2.34 UC1.AK25
DDR_B_D31: JDIMM2.36 UC1.AL25
DDR_B_D32: JDIMM2.166 UC1.AY23
DDR_B_D33: JDIMM2.165 UC1.AW23
DDR_B_D34: JDIMM2.174 UC1.AY21
DDR_B_D35: JDIMM2.175 UC1.AW21
DDR_B_D36: JDIMM2.163 UC1.AV23
DDR_B_D37: JDIMM2.164 UC1.AU23
DDR_B_D38: JDIMM2.176 UC1.AV21
DDR_B_D39: JDIMM2.177 UC1.AU21
DDR_B_D40: JDIMM2.39 UC1.AY19
DDR_B_D41: JDIMM2.41 UC1.AW19
DDR_B_D42: JDIMM2.53 UC1.AY17
DDR_B_D43: JDIMM2.52 UC1.AW17
DDR_B_D44: JDIMM2.42 UC1.AV19
DDR_B_D45: JDIMM2.40 UC1.AU19
DDR_B_D46: JDIMM2.51 UC1.AV17
DDR_B_D47: JDIMM2.50 UC1.AU17
DDR_B_D48: JDIMM2.191 UC1.AR21
DDR_B_D49: JDIMM2.183 UC1.AR22
DDR_B_D50: JDIMM2.194 UC1.AL21
DDR_B_D51: JDIMM2.180 UC1.AM22
DDR_B_D52: JDIMM2.181 UC1.AN22
DDR_B_D53: JDIMM2.193 UC1.AP21
DDR_B_D54: JDIMM2.192 UC1.AK21
DDR_B_D55: JDIMM2.182 UC1.AK22
DDR_B_D56: JDIMM2.57 UC1.AN20
DDR_B_D57: JDIMM2.59 UC1.AR20
DDR_B_D58: JDIMM2.69 UC1.AK18
DDR_B_D59: JDIMM2.67 UC1.AL18
DDR_B_D60: JDIMM2.58 UC1.AK20
DDR_B_D61: JDIMM2.56 UC1.AM20
DDR_B_D62: JDIMM2.70 UC1.AR18
DDR_B_D63: JDIMM2.68 UC1.AP18
DDR_B_DQS0: JDIMM2.137 UC1.AV30
DDR_B_DQS1: JDIMM2.12 UC1.AW26
DDR_B_DQS2: JDIMM2.154 UC1.AM28
DDR_B_DQS3: JDIMM2.29 UC1.AM25
DDR_B_DQS4: JDIMM2.171 UC1.AV22
DDR_B_DQS5: JDIMM2.47 UC1.AW18
DDR_B_DQS6: JDIMM2.188 UC1.AM21
DDR_B_DQS7: JDIMM2.64 UC1.AM18
DDR_B_DQS#0: JDIMM2.135 UC1.AW30
DDR_B_DQS#1: JDIMM2.10 UC1.AV26
DDR_B_DQS#2: JDIMM2.152 UC1.AN28
DDR_B_DQS#3: JDIMM2.27 UC1.AN25
DDR_B_DQS#4: JDIMM2.169 UC1.AW22
DDR_B_DQS#5: JDIMM2.45 UC1.AV18
DDR_B_DQS#6: JDIMM2.186 UC1.AN21
DDR_B_DQS#7: JDIMM2.62 UC1.AN18
DDR_B_MA0: JDIMM2.98 UC1.AP40
DDR_B_MA1: JDIMM2.97 UC1.AR40
DDR_B_MA2: JDIMM2.96 UC1.AP42
DDR_B_MA3: JDIMM2.95 UC1.AR42
DDR_B_MA4: JDIMM2.92 UC1.AR45
DDR_B_MA5: JDIMM2.91 UC1.AP45
DDR_B_MA6: JDIMM2.90 UC1.AW46
DDR_B_MA7: JDIMM2.86 UC1.AY46
DDR_B_MA8: JDIMM2.89 UC1.AY47
DDR_B_MA9: JDIMM2.85 UC1.AU46
DDR_B_MA10: JDIMM2.107 UC1.AK36
DDR_B_MA11: JDIMM2.84 UC1.AV47
DDR_B_MA12: JDIMM2.83 UC1.AU47
DDR_B_MA13: JDIMM2.119 UC1.AK33
DDR_B_MA14: JDIMM2.80 UC1.AR46
DDR_B_MA15: JDIMM2.78 UC1.AP46
DDR_B_RAS#: JDIMM2.110 UC1.AM35
DDR_B_WE#: JDIMM2.113 UC1.AK35
DDR_CKE0_DIMMA: JDIMM1.73 UC1.AU43
DDR_CKE1_DIMMA: JDIMM1.74 UC1.AW43
DDR_CKE2_DIMMB: JDIMM2.73 UC1.AY49
DDR_CKE3_DIMMB: JDIMM2.74 UC1.AU50
DDR_CS0_DIMMA#: JDIMM1.114 UC1.AP33
DDR_CS1_DIMMA#: JDIMM1.121 UC1.AR32
DDR_CS2_DIMMB#: JDIMM2.114 UC1.AM32
DDR_CS3_DIMMB#: JDIMM2.121 UC1.AK32
DDR_PG_CTRL: U2303.2 UC1.AV61
DDR_XDP_SMBCLK_R1: JXDP1.53 RP46.7
DDR_XDP_SMBDAT_R1: JXDP1.51 RP46.8
DDR_XDP_WLAN_TP_SMBCLK: JDIMM1.202 JDIMM2.202 JMINI.30 JTP.5 QC1.1 R2332.2 RP46.2 RX6.1
DDR_XDP_WLAN_TP_SMBDAT: JDIMM1.200 JDIMM2.200 JMINI.32 JTP.6 QC1.4 R2331.2 RP46.1 RX31.1
DEVSLP0: RC11.1 RS8.1 UC1.P2
DGPU_HOLD_RST#: RC77.2 UC1.N4 UV13.1
DGPU_PRSNT#: RC99.1 RC100.2 UC1.R7
DGPU_PWROK: PR808.2 PU800.2 RC73.2 UC1.U6 UE1.18
DH_1.35V: PQ200.4 PU200.17
DH_CHG: PQ703.4 PQ704.4 PU701.18
DISPOFF#: DX1.1 JLVDS.37 RX9.1
DL_1.35V: PQ201.4 PU200.15
DL_CHG: PQ705.4 PU701.15
DP_HPD: Q1.1 R15.1 R17.2 U4.44
DPB_HPD: Q1.3 R17.1 UC1.C8
DPC_HPD: RC84.2 UC1.A8
DPLL_PVSS: RV247.2 RV248.2 UV1.AN32
DQA0_0: UV1.C37 UV5.U11
DQA0_1: UV1.C35 UV5.T11
DQA0_2: UV1.A35 UV5.U13
DQA0_3: UV1.E34 UV5.T13
DQA0_4: UV1.G32 UV5.M11
DQA0_5: UV1.D33 UV5.N11
DQA0_6: UV1.F32 UV5.M13
DQA0_7: UV1.E32 UV5.N13
DQA0_8: UV1.D31 UV4.F4
DQA0_9: UV1.F30 UV4.F2
DQA0_10: UV1.C30 UV4.E2
DQA0_11: UV1.A30 UV4.E4
DQA0_12: UV1.F28 UV4.A2
DQA0_13: UV1.C28 UV4.A4
DQA0_14: UV1.A28 UV4.B2
DQA0_15: UV1.E28 UV4.B4
DQA0_16: UV1.D27 UV5.B2
DQA0_17: UV1.F26 UV5.A2
DQA0_18: UV1.C26 UV5.B4
DQA0_19: UV1.A26 UV5.A4
DQA0_20: UV1.F24 UV5.F4
DQA0_21: UV1.C24 UV5.E4
DQA0_22: UV1.A24 UV5.E2
DQA0_23: UV1.E24 UV5.F2
DQA0_24: UV1.C22 UV4.M11
DQA0_25: UV1.A22 UV4.M13
DQA0_26: UV1.F22 UV4.N13
DQA0_27: UV1.D21 UV4.N11
DQA0_28: UV1.A20 UV4.T13
DQA0_29: UV1.F20 UV4.U13
DQA0_30: UV1.D19 UV4.U11
DQA0_31: UV1.E18 UV4.T11
DQA1_0: UV1.C18 UV3.U11
DQA1_1: UV1.A18 UV3.U13
DQA1_2: UV1.F18 UV3.T11
DQA1_3: UV1.D17 UV3.N11
DQA1_4: UV1.A16 UV3.T13
DQA1_5: UV1.F16 UV3.M13
DQA1_6: UV1.D15 UV3.N13
DQA1_7: UV1.E14 UV3.M11
DQA1_8: UV1.F14 UV6.F4
DQA1_9: UV1.D13 UV6.F2
DQA1_10: UV1.F12 UV6.E2
DQA1_11: UV1.A12 UV6.E4
DQA1_12: UV1.D11 UV6.A2
DQA1_13: UV1.F10 UV6.B4
DQA1_14: UV1.A10 UV6.A4
DQA1_15: UV1.C10 UV6.B2
DQA1_16: UV1.G13 UV3.B4
DQA1_17: UV1.H13 UV3.B2
DQA1_18: UV1.J13 UV3.A2
DQA1_19: UV1.H11 UV3.A4
DQA1_20: UV1.G10 UV3.E4
DQA1_21: UV1.G8 UV3.F2
DQA1_22: UV1.K9 UV3.F4
DQA1_23: UV1.K10 UV3.E2
DQA1_24: UV1.G9 UV6.N11
DQA1_25: UV1.A8 UV6.M13
DQA1_26: UV1.C8 UV6.N13
DQA1_27: UV1.E8 UV6.M11
DQA1_28: UV1.A6 UV6.T13
DQA1_29: UV1.C6 UV6.U13
DQA1_30: UV1.E6 UV6.T11
DQA1_31: UV1.A5 UV6.U11
DQB0_0: UV1.C5 UV7.T13
DQB0_1: UV1.C3 UV7.U13
DQB0_2: UV1.E3 UV7.U11
DQB0_3: UV1.E1 UV7.T11
DQB0_4: UV1.F1 UV7.N11
DQB0_5: UV1.F3 UV7.M13
DQB0_6: UV1.F5 UV7.M11
DQB0_7: UV1.G4 UV7.N13
DQB0_8: UV1.H5 UV8.F2
DQB0_9: UV1.H6 UV8.F4
DQB0_10: UV1.J4 UV8.E4
DQB0_11: UV1.K6 UV8.E2
DQB0_12: UV1.K5 UV8.A2
DQB0_13: UV1.L4 UV8.B2
DQB0_14: UV1.M6 UV8.A4
DQB0_15: UV1.M1 UV8.B4
DQB0_16: UV1.M3 UV8.M11
DQB0_17: UV1.M5 UV8.M13
DQB0_18: UV1.N4 UV8.N13
DQB0_19: UV1.P6 UV8.N11
DQB0_20: UV1.P5 UV8.T13
DQB0_21: UV1.R4 UV8.U13
DQB0_22: UV1.T6 UV8.U11
DQB0_23: UV1.T1 UV8.T11
DQB0_24: UV1.U4 UV7.A4
DQB0_25: UV1.V6 UV7.B4
DQB0_26: UV1.V1 UV7.B2
DQB0_27: UV1.V3 UV7.A2
DQB0_28: UV1.Y6 UV7.E4
DQB0_29: UV1.Y1 UV7.F2
DQB0_30: UV1.Y3 UV7.E2
DQB0_31: UV1.Y5 UV7.F4
DQB1_0: UV1.AA4 UV10.F4
DQB1_1: UV1.AB6 UV10.F2
DQB1_2: UV1.AB1 UV10.E4
DQB1_3: UV1.AB3 UV10.E2
DQB1_4: UV1.AD6 UV10.B4
DQB1_5: UV1.AD1 UV10.A4
DQB1_6: UV1.AD3 UV10.A2
DQB1_7: UV1.AD5 UV10.B2
DQB1_8: UV1.AF1 UV9.U11
DQB1_9: UV1.AF3 UV9.N11
DQB1_10: UV1.AF6 UV9.T11
DQB1_11: UV1.AG4 UV9.U13
DQB1_12: UV1.AH5 UV9.T13
DQB1_13: UV1.AH6 UV9.M13
DQB1_14: UV1.AJ4 UV9.N13
DQB1_15: UV1.AK3 UV9.M11
DQB1_16: UV1.AF8 UV9.A4
DQB1_17: UV1.AF9 UV9.B4
DQB1_18: UV1.AG8 UV9.A2
DQB1_19: UV1.AG7 UV9.B2
DQB1_20: UV1.AK9 UV9.E4
DQB1_21: UV1.AL7 UV9.F2
DQB1_22: UV1.AM8 UV9.E2
DQB1_23: UV1.AM7 UV9.F4
DQB1_24: UV1.AK1 UV10.M11
DQB1_25: UV1.AL4 UV10.M13
DQB1_26: UV1.AM6 UV10.N13
DQB1_27: UV1.AM1 UV10.N11
DQB1_28: UV1.AN4 UV10.T13
DQB1_29: UV1.AP3 UV10.T11
DQB1_30: UV1.AP1 UV10.U13
DQB1_31: UV1.AP5 UV10.U11
DRAM_RST#: RV138.2 RV143.1 UV3.J2 UV4.J2 UV5.J2 UV6.J2 UV7.J2 UV8.J2 UV9.J2 UV10.J2
DRAM_RST#_R: RV144.2 RV145.2 UV1.AH11
DROOP_CPU: PC513.2 PR529.2 PR532.1 PU501.25
DSWODVREN: R2337.1 R2338.1 UC1.AW7
EC_ENVDD: RX8.2 UE1.71
EC_LID_OUT#: UC1.AD6 UE1.101
EC_MUTE#: UA1.47 UE1.83
EC_ON: PR102.1 UE1.112
EC_RSMRST#: RC41.1 RE2.2 UE1.100
EC_RST#: CE11.1 RE8.1 UE1.37
EC_RX: JMINI.51 RM13.1 UE1.31
EC_SCI#: UC1.AM2 UE1.20
EC_SMB_CK1: PR18.2 PR714.1 RP36.4 UE1.77
EC_SMB_CK2: QH1.6 QV15.6 QX6.3 RP36.2 UE1.79
EC_SMB_DA1: PR20.2 PR715.1 RP36.3 UE1.78
EC_SMB_DA2: QH1.3 QV15.3 QX6.6 RP36.1 UE1.80
EC_SMI#: RC107.1 UC1.V1 UE1.15
EC_SPI_CLK_R: T185.1(TP-1) UE1.126
EC_SPI_CS0#: T186.1(TP-1) UE1.128
EC_SPI_MISO_1: T184.1(TP-1) UE1.120
EC_SPI_MOSI_1: T183.1(TP-1) UE1.119
EC_TX: JMINI.49 RM11.2 UE1.30
ECAGND: CE7.2 CE9.1 LE2.2 PH1.2 UE1.69
EDCA0_0: UV1.C34 UV5.R13
EDCA0_1: UV1.D29 UV4.C2
EDCA0_2: UV1.D25 UV5.C2
EDCA0_3: UV1.E20 UV4.R13
EDCA1_0: UV1.E16 UV3.R13
EDCA1_1: UV1.E12 UV6.C2
EDCA1_2: UV1.J10 UV3.C2
EDCA1_3: UV1.D7 UV6.R13
EDCB0_0: UV1.F6 UV7.R13
EDCB0_1: UV1.K3 UV8.C2
EDCB0_2: UV1.P3 UV8.R13
EDCB0_3: UV1.V5 UV7.C2
EDCB1_0: UV1.AB5 UV10.C2
EDCB1_1: UV1.AH1 UV9.R13
EDCB1_2: UV1.AJ9 UV9.C2
EDCB1_3: UV1.AM5 UV10.R13
EDID_CLK: JLVDS.34 RP56.3 UX4.46
EDID_DATA: JLVDS.35 RP56.4 UX4.45
EDP_AUX: RX39.2 RX40.1
EDP_AUX#: RX37.2 RX38.1
EDP_BIA_PWM: RC72.2 RC75.2 RC81.2 RX36.1 RX49.1 UX4.21
EDP_BKLCTL: RC81.1 UC1.B8
EDP_COMP: RC71.2 UC1.D20
EDP_CPU_AUX: CX43.1 RX25.1 UC1.B45
EDP_CPU_AUX#: CX44.1 RX30.2 UC1.A45
EDP_CPU_HPD: QC3.2 RC105.1 RX35.1 RX52.1 UX4.1
EDP_CPU_LANE_N0: CX46.1 UC1.C45
EDP_CPU_LANE_N1: CX39.1 UC1.A47
EDP_CPU_LANE_P0: CX42.1 UC1.B46
EDP_CPU_LANE_P1: CX38.1 UC1.B47
EDP_DISP_UTIL: RC72.1 UC1.A43
EDP_HPD_PANEL: RX52.2 RX53.1
EDP_N0: RX43.2 RX44.1
EDP_N1: RX47.2 RX48.1
EDP_P0: RX41.2 RX42.1
EDP_P1: RX45.2 RX46.1
EN_0.675VSP: PC203.1 PR202.2 PU200.7
EN_1.35V: PC202.1 PR201.2 PU200.8
EN_+1.2VSP: PC1104.1 PR1103.2 PU1100.3
EN_DFAN1: UE1.70 UE3.4
EN_INVPWR: QX1.2 UE1.68
EN_PCIE: PC1307.1 PR1300.2 PR1304.1 PU1300.5
ENVDD_PCH: RC87.2 RX51.1 UC1.C6 UE1.19
ENVDD_R: RX7.1 RX8.1 UX1.3
ERP_LOT6: PC5.1 PQ1.2 PR1.2 PR2.1 UE1.73
F-IMAX: PR504.1 PR505.2 PU501.10
FAN_SPEED1: CE24.1 CE29.1 JFAN.2 RE50.2 UE1.28
FB_1.5VSP: PC404.2 PR402.1 PR403.2 PU400.1
FB_1.8VSP: PC604.2 PR602.1 PR603.2 PU600.1
FB_1.35V: PR204.1 PR207.1 PU200.6
FB_3V: PC102.2 PR107.2 PR109.2 PU100.4
FB_5V: PC108.1 PR104.1 PR106.1 PU100.2
FB_+1.2VSP: PR1107.1 PR1108.1 PU1100.4
FB_PCIE: PC1306.2 PR1301.1 PR1302.2 PU1300.6
GCLK_VRTC: CG5.1 RG1.2 UG1.10
GENLK_CLK: T80.1(TP-1) UV1.AD29
GENLK_VSYNC: T81.1(TP-1) UV1.AC29
GFX_FB-1: PC806.1 PR821.2
GFX_FB-2: PC817.1 PR818.2
GPIO21_BBEN: T78.1(TP-1) UV1.AJ14
GPIO24_TRSTB: RP47.8 UV1.AM23
GPIO25_TDI: RP47.7 UV1.AN23
GPIO26_TCK: RP47.5 UV1.AK23
GPIO27_TMS: RP47.6 UV1.AL24
GPIO28_TDO: T79.1(TP-1) UV1.AM24
GPU_B+: PC804.1 PC805.1 PC808.1 PC831.1 PC832.1 PL800.2 PQ800.5 PQ803.5 PR823.2
GPU_GPIO0: RV75.2 UV1.AH20
GPU_GPIO1: RV76.2 UV1.AH18
GPU_GPIO2: RP60.8 UV1.AN16
GPU_GPIO6: PR1212.1 PR1213.2 PR1214.1 UV1.AJ17
GPU_GPIO8: RP60.6 UV1.AJ13
GPU_GPIO9: RP60.5 UV1.AH15
GPU_GPIO11: RV81.2 UV1.AK16
GPU_GPIO12: RV82.2 UV1.AL16
GPU_GPIO13: RV83.2 UV1.AM16
GPU_RST#: RV66.1 UV1.AA30 UV13.4
GPU_THERMAL_D+: CV89.1 UV1.AF29 UV14.2
GPU_THERMAL_D-: CV89.2 UV1.AG29 UV14.3
GPU_VGA_B: T87.1(TP-1) UV1.AF37
GPU_VGA_DDCCLK: T90.1(TP-1) UV1.AK30
GPU_VGA_DDCDAT: T91.1(TP-1) UV1.AK29
GPU_VGA_G: T86.1(TP-1) UV1.AE36
GPU_VGA_HSYNC: T88.1(TP-1) UV1.AC36
GPU_VGA_R: T85.1(TP-1) UV1.AD39
GPU_VGA_VSYNC: T89.1(TP-1) UV1.AC38
GPU_VID1: PR810.1 PR819.2 PR828.2 UV1.AL13
GPU_VID2: PR812.1 PR826.2 PR834.2 UV1.AK14
GPU_VID3: PR807.1 PR835.2 PR836.2 UV1.AM13
GPU_VID4: PR809.1 PR837.2 PR838.2 UV1.AM14
GPU_VID5: PR806.1 PR839.2 PR840.2 UV1.AJ16
GREEN_CRT: C3.1 L8.1 R33.1 U4.9
GREEN_CRT_L: C6.1 DE4.3 JCRT1.2 L8.2
H_CATERR#: RC58.2 UC1.K61
H_CPU_SVIDALRT#: R254.1 UC1.L62
H_CPU_SVIDCLK: C5212.1 R248.2 UC1.N63
H_CPU_SVIDDATA: R256.2 R257.1 UC1.L63
H_CPUPWRGD: CC27.1 RC48.1 RC66.1 UC1.C61
H_PROCHOT#: CE19.1 PQ2.6 PQ3.3 PQ3.6 RC60.2 RC67.1 RE44.2 UE2.4
H_PROCHOT#_R: RC67.2 UC1.K63
H_THERMTRIP#: R2346.2 UC1.D60
H_VCCST_PWRGD_XDP: JXDP1.39 RC48.2
H_VR_READY: PR524.2 PR540.2 PU501.3 R251.1
HDA_SPKR: DA8.3 RC121.2 UC1.V2
HDD_DET#: JHDD.12 RC9.1 UC1.AG6
HOST_ALERT1_R_N: RC120.2 UC1.AD7
HPOUT-L: RA55.1 UA1.32
HPOUT-R: RA56.1 UA1.33
HSYNC_BUF: R13.1 U4.2
HSYNC_BUF_L: R3.1 U1.4
I2C0_SCL: RP53.4 UC1.F3
I2C0_SDA: RP53.3 UC1.F2
I2C1_SCL_TCH_PAD: RP53.2 UC1.F1
I2C1_SDA_TCH_PAD: RP53.1 UC1.G4
ILMT_1.05V: PR304.2 PR306.1 PU300.3
ILMT_VDDCI: PR1202.1 PR1203.2 PU1200.3
IMON_CPU: PC508.2 PR501.2 PU501.13
IMVP_PWRGD: PC523.1 PR540.1 UE1.85
INT-SPK-L+: LA6.1 UA1.42
INT-SPK-L-: LA5.1 UA1.43
INT-SPK-R+: LA4.1 UA1.45
INT-SPK-R-: LA3.1 UA1.44
INTRUDER#: RC7.2 UC1.AU6
ISOLATEB: RL33.2 RL35.2 UL1.20
ISPSCL_R: R20.1 R42.1 U4.19
ISPSDA_R: R21.1 R37.1 U4.20
ISUM+: PC819.1 PC820.1 PR816.1 PR827.1 PR829.2 PU800.10
ISUM-: PR825.1 PU800.9
ISUM-1: PC819.2 PC820.2 PC821.2 PH800.2 PR825.2 PR827.2 PR830.2
ISUM-2: PH800.1 PR816.2
JACK_PLUG#: JHP.5 RA1.2 RA3.1 RA4.1
JACK_SENSE#: QA5.3 RA4.2 RA51.2
JHDD_P10: JHDD.10 RS7.2 RS8.2
KB_CAPS_PWR: JKB.4 RE60.2
KB_RST#: RP43.8 UC1.V4 UE1.2
KSI0: JKB.22 UE1.55
KSI1: JKB.24 UE1.56
KSI2: JKB.26 UE1.57
KSI3: JKB.23 UE1.58
KSI4: JKB.27 UE1.59
KSI5: JKB.25 UE1.60
KSI6: JKB.28 UE1.61
KSI7: JKB.29 UE1.62
KSO0: JKB.13 UE1.39
KSO1: JKB.15 UE1.40
KSO2: JKB.14 UE1.41
KSO3: JKB.16 UE1.42
KSO4: JKB.20 UE1.43
KSO5: JKB.21 UE1.44
KSO6: JKB.18 UE1.45
KSO7: JKB.19 UE1.46
KSO8: JKB.17 UE1.47
KSO9: JKB.7 UE1.48
KSO10: JKB.5 UE1.49
KSO11: JKB.6 UE1.50
KSO12: JKB.12 UE1.51
KSO13: JKB.9 UE1.52
KSO14: JKB.8 UE1.53
KSO15: JKB.10 UE1.54
KSO16: JKB.11 UE1.81
LAN_CLKREQ#: RL37.1 RP42.8 UC1.AD1 UL1.12
LAN_X1_R: RG5.1 UG1.6
LCD_CBL_DET#: RC106.2 UC1.J3
LCD_TEST: JLVDS.33 UE1.72
LDO_3V: PC312.1 PR304.1 PU300.5
LDO_3V_VDDCI: PC1213.1 PR1203.1 PU1200.5
LG_3V: PQ102.4 PU100.11
LG_5V: PQ104.4 PU100.15
LG_+1.2VSP: PQ1101.4 PU1100.6
LID_SW#: CE30.1 JPWR.2 RE71.2 UE1.115
LINE1-L: CA67.1 UA1.22
LINE1-R: CA68.1 UA1.21
LINE1-VREFO-L: RA165.1 UA1.31
LINE1-VREFO-R: RA166.1 UA1.30
LINE-IN-L: LA8.2 RA55.2 RA80.2 RA83.1 RA165.2
LINE-IN-R: LA9.2 RA56.2 RA82.2 RA84.1 RA166.2
LPC_LAD0: UC1.AU14 UE1.10
LPC_LAD1: UC1.AW12 UE1.8
LPC_LAD2: UC1.AY12 UE1.7
LPC_LAD3: UC1.AW11 UE1.5
LPC_LFRAME#: UC1.AV12 UE1.4
LVDS_A0+: JLVDS.2 UX4.41
LVDS_A0-: JLVDS.1 UX4.42
LVDS_A1+: JLVDS.5 UX4.39
LVDS_A1-: JLVDS.4 UX4.40
LVDS_A2+: JLVDS.8 UX4.37
LVDS_A2-: JLVDS.7 UX4.38
LVDS_ACLK+: JLVDS.11 UX4.35
LVDS_ACLK-: JLVDS.10 UX4.36
LVDS_B0+: JLVDS.14 RX40.2 UX4.31
LVDS_B0-: JLVDS.13 RX38.2 UX4.32
LVDS_B1+: JLVDS.17 RX44.2 UX4.29
LVDS_B1-: JLVDS.16 RX42.2 UX4.30
LVDS_B2+: JLVDS.20 RX48.2 UX4.27
LVDS_B2-: JLVDS.19 RX46.2 UX4.28
LVDS_BCLK+: JLVDS.23 UX4.25
LVDS_BCLK-: JLVDS.22 UX4.26
LX_1.05V: PC302.2 PL301.1 PR302.1 PU300.10
LX_1.5VSP: PL400.1 PR405.1 PU400.6
LX_1.8VSP: PL600.1 PR605.1 PU600.6
LX_3V: PC104.1 PL100.1 PQ101.1 PQ101.2 PQ101.3 PQ102.5 PR113.1 PU100.8
LX_5V: PC110.2 PL101.1 PQ103.1 PQ103.2 PQ103.3 PQ104.5 PR112.1 PU100.18
LX_CHG: PC715.1 PC721.2 PL701.1 PQ703.1 PQ703.2 PQ703.3 PQ704.1 PQ704.2 PQ704.3 PQ705.5 PU701.19
LX_PCIE: PL1300.1 PR1303.1 PU1300.1 PU1300.2 PU1300.3
LX_VDDCI: PC1210.2 PL1200.1 PR1207.1 PU1200.10
M_CLK_DDR0: JDIMM1.101 UC1.AV37
M_CLK_DDR1: JDIMM1.102 UC1.AY36
M_CLK_DDR2: JDIMM2.101 UC1.AN38
M_CLK_DDR3: JDIMM2.102 UC1.AL38
M_CLK_DDR#0: JDIMM1.103 UC1.AU37
M_CLK_DDR#1: JDIMM1.104 UC1.AW36
M_CLK_DDR#2: JDIMM2.103 UC1.AM38
M_CLK_DDR#3: JDIMM2.104 UC1.AK38
M_ODT: CD64.1 QD2.3 R2348.1 R2349.1 R2350.1 R2352.1
M_ODT0: JDIMM1.116 R2348.2
M_ODT1: JDIMM1.120 R2349.2
M_ODT2: JDIMM2.116 R2350.2
M_ODT3: JDIMM2.120 R2352.2
MAA0_0: UV1.G24 UV4.H4 UV5.K4
MAA0_1: UV1.J23 UV4.H5 UV5.K5
MAA0_2: UV1.H24 UV4.H11 UV5.K11
MAA0_3: UV1.J24 UV4.H10 UV5.K10
MAA0_4: UV1.H26 UV4.K11 UV5.H11
MAA0_5: UV1.J26 UV4.K10 UV5.H10
MAA0_6: UV1.H21 UV4.K5 UV5.H5
MAA0_7: UV1.G21 UV4.K4 UV5.H4
MAA0_8: UV1.H23 UV4.J5 UV5.J5
MAA1_0: UV1.H19 UV3.K4 UV6.H4
MAA1_1: UV1.H20 UV3.K5 UV6.H5
MAA1_2: UV1.L13 UV3.K11 UV6.H11
MAA1_3: UV1.G16 UV3.K10 UV6.H10
MAA1_4: UV1.J16 UV3.H11 UV6.K11
MAA1_5: UV1.H16 UV3.H10 UV6.K10
MAA1_6: UV1.J17 UV3.H5 UV6.K5
MAA1_7: UV1.H17 UV3.H4 UV6.K4
MAA1_8: UV1.J19 UV3.J5 UV6.J5
MAB0_0: UV1.P8 UV7.K4 UV8.H4
MAB0_1: UV1.T9 UV7.K5 UV8.H5
MAB0_2: UV1.P9 UV7.K11 UV8.H11
MAB0_3: UV1.N7 UV7.K10 UV8.H10
MAB0_4: UV1.N8 UV7.H11 UV8.K11
MAB0_5: UV1.N9 UV7.H10 UV8.K10
MAB0_6: UV1.U9 UV7.H5 UV8.K5
MAB0_7: UV1.U8 UV7.H4 UV8.K4
MAB0_8: UV1.T8 UV7.J5 UV8.J5
MAB1_0: UV1.Y9 UV9.K4 UV10.H4
MAB1_1: UV1.W9 UV9.K5 UV10.H5
MAB1_2: UV1.AC8 UV9.K11 UV10.H11
MAB1_3: UV1.AC9 UV9.K10 UV10.H10
MAB1_4: UV1.AA7 UV9.H11 UV10.K11
MAB1_5: UV1.AA8 UV9.H10 UV10.K10
MAB1_6: UV1.Y8 UV9.H5 UV10.K5
MAB1_7: UV1.AA9 UV9.H4 UV10.K4
MAB1_8: UV1.W8 UV9.J5 UV10.J5
MCT0: RL19.1 TL2.22
MCT1: RL20.1 TL2.21
MCT2: RL39.1 TL2.16
MCT3: RL40.1 TL2.15
MCURSTN: C90.2 R19.2 U4.53
