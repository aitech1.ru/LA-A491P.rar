# Allegro board LAA491PR10-0624.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_WLAN on TOP (solid shape): 94.75,149.15 94.75,147.76 94.44,147.46 94.44,146.66 94.59,146.52 94.59,145.9 94.52,145.84 92.89,145.84 92.52,146.21 92.52,148.95 92.84,149.27 94.63,149.27
+3V_WLAN on TOP (solid shape): 112.81,150.68 112.81,149.38 113.12,149.07 113.12,147.97 113.02,147.87 112.31,147.87 112.22,147.96 112.22,148.17 112.09,148.3 111.45,148.3 111.35,148.39 111.35,150.7 111.4,150.75 112.74,150.75
+3V_WLAN on TOP (solid shape): 119.22,149.9 119.41,149.71 119.41,147.52 119.23,147.34 118.16,147.34 118.15,147.34 117.97,147.38 117.79,147.34 117.78,147.34 117.57,147.34 117.49,147.37 117.38,147.48 117.38,148.09 117.2,148.28 116.61,148.28 116.48,148.41 116.48,149.04 116.48,149.04 116.48,149.44 116.68,149.64 116.68,149.64 116.94,149.9 118.86,149.9
+3V_WLAN on BOTTOM (solid shape): 94.01,149.15 94.01,147.39 93.76,147.14 92.8,147.14 92.49,147.46 92.49,148.86 92.83,149.2 93.96,149.2
+3V_WLAN on BOTTOM (solid shape): 119.28,149.68 119.28,148.19 118.49,147.4 117.32,147.4 117.09,147.16 116.83,147.16 116.59,147.41 116.59,149.52 116.85,149.78 119.18,149.78
+3V_WLAN on BOTTOM (solid shape): 106.01,149.15 106.01,147.25 106.2,147.06 106.38,147.06 106.38,147.06 106.51,147.04 106.63,147.06 106.64,147.06 106.8,147.06 106.94,146.92 106.94,146.54 106.89,146.48 105.46,146.48 105.22,146.72 105.22,147.05 105.37,147.19 105.37,149.09 105.47,149.2 105.96,149.2
+3V_WLAN on IN1 (solid shape): 112.83,150.69 112.83,149.96 112.83,149.96 112.83,149.47 113.25,149.04 115.22,149.04 115.93,149.76 119.38,149.76 119.76,149.38 119.76,147.68 119.47,147.39 117.19,147.39 117.06,147.27 114.23,147.27 114.23,147.27 114.1,147.29 113.98,147.27 113.97,147.27 113.44,147.27 113.43,147.27 113.31,147.29 113.19,147.27 113.19,147.27 108.25,147.27 107.75,146.76 107.59,146.6 105.3,146.6 105.09,146.81 105.09,146.82 105.03,146.97 104.91,147.07 104.9,147.08 104.58,147.39 92.49,147.39 92.17,147.71 92.17,149.59 92.35,149.77 95.47,149.77 95.55,149.73 95.57,149.64 95.91,149.2 96.26,149.64 96.28,149.73 96.36,149.77 105.76,149.77 106.25,149.27 106.28,149.27 106.29,149.26 106.58,149.21 106.81,149.38 106.9,149.43 106.99,149.38 107.43,149.22 107.65,149.64 107.66,149.73 107.74,149.77 111.15,149.77 111.35,149.96 111.35,150.71 111.39,150.75 112.77,150.75
+3VALW on TOP (solid shape): 46.96,82.81 46.96,80.34 46.64,80.02 45.75,80.02 45.5,80.27 45.5,82.88 45.62,83 46.77,83
+3VALW on TOP (solid shape): 48.16,29.98 48.16,27.76 47.97,27.57 46.96,27.57 46.7,27.82 46.7,30.05 46.89,30.24 47.91,30.24
+3VALW on TOP (solid shape): 207.48,51.64 207.48,50.3 207.29,50.11 203.74,50.11 203.36,50.49 203.36,51.51 203.74,51.89 207.23,51.89
+3VALW on TOP (solid shape): 199.61,55.51 199.61,54.18 199.23,53.79 198.21,53.79 197.7,54.3 197.01,54.3 196.82,54.49 196.82,55.57 196.43,55.95 195.29,55.95 194.34,56.91 194.34,57.73 194.66,58.05 197.07,58.05
+3VALW on TOP (solid shape): 191.3,55.85 191.3,55.26 191.13,55.15 191.05,54.96 191.05,54.94 190.94,54.83 188.98,54.83 188.85,54.96 188.85,56.06 188.94,56.14 191.01,56.14
+3VALW on TOP (solid shape): 200.85,39.11 200.85,38.22 199.92,37.28 199.92,36.5 200.1,36.32 200.1,35.18 199.95,35.03 198.76,35.03 198.23,35.57 198.23,37.24 198.53,37.54 199.36,37.54 199.61,37.79 199.61,38.21 200.04,38.64 200.04,39.21 200.13,39.29 200.67,39.29
+3VALW on TOP (solid shape): outline of 95 points within 132.28,10.62 143.78,22.49
+3VALW on BOTTOM (solid shape): 195.81,57.76 196.69,56.88 196.69,56.27 196.31,55.89 194.56,55.89 193.54,56.91 193.54,57.76 193.63,57.85 195.73,57.85
+3VALW on BOTTOM (solid shape): 144.83,158.43 144.83,157.1 145.07,156.86 145.07,155.23 144.79,155.23 144.79,156.36 144.18,156.97 144.18,158.45 144.29,158.56 144.7,158.56
+3VALW on BOTTOM (solid shape): 214.17,91.82 214.17,91.35 214.72,91.35 214.72,91.07 214.2,91.07 214.2,90.56 214.72,90.56 214.72,90.29 214.17,90.29 214.17,89.8 213.71,89.34 211.35,89.34 211.19,89.5 211.19,91.69 211.41,91.91 214.08,91.91
+3VALW on BOTTOM (solid shape): 41.92,104.68 42.47,104.68 42.47,105.23 42.72,105.23 42.72,104.68 43.3,104.68 43.46,104.52 43.46,102.36 43.15,102.04 41.3,102.04 41.05,102.3 41.05,104.56 41.17,104.69 41.67,104.69 41.67,105.23 41.92,105.23
+3VALW on BOTTOM (solid shape): 108.02,20.55 108.57,20.55 108.57,21.1 108.82,21.1 108.82,20.52 109.44,20.52 109.69,20.27 109.69,19.19 109.5,19 105.63,19 105.31,19.31 105.31,20.27 105.57,20.52 107.76,20.52 107.76,20.58 107.77,20.58 107.77,21.1 108.02,21.1
+3VALW on BOTTOM (solid shape): 47.81,86.47 47.81,84.37 47.4,83.96 47.4,80.34 47.15,80.08 43.54,80.08 43.47,80.15 43.47,80.78 43.57,80.88 45.01,80.88 45.75,81.62 45.75,84.29 45.95,84.49 45.95,85.21 45.42,85.21 45.42,85.38 45.95,85.38 45.95,86.38 46.26,86.69 47.59,86.69
+3VALW on BOTTOM (solid shape): 95.09,29.41 95.09,28.9 95.22,28.78 95.85,28.78 95.91,28.71 95.91,27.74 95.86,27.55 95.91,27.36 95.91,25.98 95.72,25.79 93.44,25.79 93.18,26.05 93.18,27.39 93.18,29.34 93.18,29.47 93.31,29.6 94.9,29.6
+3VALW on BOTTOM (solid shape): 139.07,12.51 139.1,12.51 139.8,12.51 139.82,12.51 139.82,13.03 140.27,13.03 140.27,12.51 140.3,12.51 141,12.51 141,13.03 142.08,13.03 142.4,12.71 142.4,11.5 142.08,11.19 132.87,11.19 132.55,11.5 132.55,12.9 132.68,13.03 133.82,13.03 133.82,12.51 134.53,12.51 134.55,12.51 134.55,13.03 135,13.03 135,12.51 135.02,12.51 135.73,12.51 135.75,12.51 135.75,13.03 138.9,13.03 138.9,13.03 139.07,13.03
+3VALW on IN2 (solid shape): 208.82,51.51 208.82,49.79 208.31,49.29 204.44,49.29 203.67,50.05 203.67,51.25 204.18,51.76 208.56,51.76
+3VALW on IN2 (solid shape): 212.5,90.56 212.5,88.99 212.25,88.74 211.51,88.74 211.29,88.96 211.29,90.55 211.47,90.73 212.33,90.73
+3VALW on IN2 (solid shape): 198.55,24.44 198.55,20.85 198.28,20.58 196.56,20.58 196.18,20.97 196.18,24.27 196.69,24.78 198.21,24.78
+3VALW on IN3 (solid shape): 43.09,102.6 43.09,100.7 43.04,100.64 41.88,100.64 41.65,100.88 41.65,102.55 41.82,102.73 42.97,102.73
+3VALW on IN3 (solid shape): 47.51,87.84 47.51,85.96 47.39,85.84 46.24,85.84 46.04,86.04 46.04,87.84 46.19,88 47.35,88
+3VALW on VCC: 176.79,8.84 168.47,17.16 157.91,17.16 155.44,14.68 145.21,14.68 141.97,11.44 132.85,11.44 129.61,14.68 124.59,14.68 119.83,19.44 40.46,19.44 39.27,20.63 39.27,28.39 92.53,28.33 93.73,29.54 97.15,29.54 98.48,28.27 172.83,28.39 178.87,22.36 205.54,22.36 207.29,20.61 207.29,8.94 207.19,8.84
+3VALW_PCH on TOP (solid shape): 122.96,51.29 122.96,50.23 122.7,49.98 121.88,49.98 121.7,50.16 121.7,51.41 121.81,51.52 122.73,51.52
+3VALW_PCH on TOP (solid shape): 132.83,110.96 132.83,109.96 132.74,109.87 130.69,109.87 130.53,110.02 130.53,110.43 130.62,110.51 131.61,110.51 131.71,110.6 131.71,110.98 131.81,111.09 132.71,111.09
+3VALW_PCH on TOP (solid shape): 142.76,30.37 142.76,26.87 142.64,26.75 141.75,26.75 141.38,27.12 138.14,27.12 138.01,27.25 138.01,30.43 138.46,30.87 142.25,30.87
+3VALW_PCH on TOP (solid shape): 156.65,93.26 161.92,93.26 162.14,93.04 162.14,92.4 162.02,92.28 156.91,92.28 156.68,92.05 155.68,92.05 151.9,95.82 136.72,95.82 136.45,96.09 136.45,96.69 136.7,96.94 152.97,96.94
+3VALW_PCH on TOP (solid shape): outline of 107 points within 147.54,108.34 151.46,114.21
+3VALW_PCH on BOTTOM (solid shape): 122.97,52.15 122.97,51.1 122.72,50.84 121.89,50.84 121.71,51.03 121.71,52.27 121.82,52.38 122.74,52.38
+3VALW_PCH on BOTTOM (solid shape): 148.81,109.13 148.81,106.74 149.04,106.51 149.04,104.6 148.85,104.4 147.55,104.4 147.55,104.41 147.37,104.41 147.27,104.51 147.27,105.24 147.7,105.67 147.7,109.1 147.86,109.26 148.68,109.26
+3VALW_PCH on BOTTOM (solid shape): 147.54,113.03 147.54,112.34 147.81,112.08 148.3,112.08 148.39,111.99 148.39,111.47 148.36,111.44 147.79,111.44 147.62,111.62 145.68,111.62 145.65,112.23 145.7,112.28 145.7,113 145.8,113.1 147.47,113.1
+3VALW_PCH on BOTTOM (solid shape): 141.14,112.75 141.14,111.2 141.09,111.15 140.82,110.74 141.21,110.45 141.28,110.42 141.32,110.35 141.32,108.91 141.19,108.79 139.69,108.79 139.22,108.32 138.92,108.32 138.6,108.63 138.6,108.8 139.25,109.45 139.25,109.77 139.35,109.87 140,109.87 140.2,110.08 140.2,110.99 139.27,111.92 139.27,113.59 139.35,113.67 140.22,113.67
+3VALW_PCH on BOTTOM (solid shape): 164.13,91.31 164.13,86.64 163.99,86.5 162.59,86.5 162.44,86.64 162.44,90.27 161.05,91.67 161.05,91.69 162.36,91.69 162.36,91.64 162.38,91.59 162.39,91.54 162.42,91.49 162.45,91.45 162.49,91.41 162.54,91.38 162.59,91.36 162.64,91.34 162.69,91.34 162.74,91.34 162.8,91.34 162.85,91.36 162.89,91.38 162.94,91.41 162.98,91.45 163.01,91.49 163.04,91.54 163.06,91.59 163.07,91.64 163.07,91.69 163.07,91.74 163.06,91.8 163.04,91.85 163.01,91.89 162.98,91.93 162.94,91.97 162.89,92 162.85,92.02 162.8,92.04 162.74,92.05 162.69,92.05 162.64,92.04 162.59,92.02 162.54,92 162.49,91.97 162.45,91.93 162.42,91.89 162.39,91.85 162.38,91.8 162.36,91.74 162.36,91.69 161.05,91.69 161.05,92.92 161.32,93.19 162.25,93.19
+3VALW_PCH on IN1 (solid shape): outline of 207 points within 131.72,110.63 147.54,114.98
+3VALW_PCH on IN1 (solid shape): outline of 265 points within 135.35,91.13 157.21,108.13
+3VALW_PCH on IN2 (solid shape): 148.14,111.89 148.14,110.06 148.97,109.22 148.97,106.3 152.3,102.97 152.3,99.77 152.19,99.66 150.94,99.66 150.87,99.74 150.87,102.95 149.62,104.2 147.66,104.2 146.96,104.89 146.96,106.44 147.02,106.53 147.12,106.53 147.67,106.82 147.12,107.12 147.02,107.11 146.96,107.2 146.96,110.77 146.04,111.7 146.04,112.69 146.29,112.94 147.08,112.94
+3VALW_PCH on IN3 (solid shape): 151.29,114.26 151.29,112.51 150.24,111.47 146.54,111.47 146.38,111.63 146.38,112.9 146.84,113.36 147.73,113.36 149.15,114.78 150.77,114.78
+3VALWP on BOTTOM (solid shape): 141.06,26.39 141.06,18.55 141.89,17.73 141.89,13.41 141.76,13.28 141.75,13.28 141.67,13.2 140.89,13.2 140.87,13.18 140.87,12.64 140.4,12.64 140.4,13.16 139.7,13.16 139.7,12.64 139.2,12.64 139.2,13.16 138.42,13.16 138.42,13.15 136.4,13.15 136.4,13.16 135.62,13.16 135.62,12.64 135.13,12.64 135.13,13.16 134.42,13.16 134.42,12.64 133.98,12.64 133.98,13.2 133.21,13.2 132.97,13.44 132.97,14.77 134.27,16.08 134.27,20.2 136.94,22.87 136.94,27.22 137.13,27.41 140.05,27.41
+3VGS on TOP (solid shape): 175.62,115.08 175.62,114.52 175.73,114.4 176.64,114.4 176.76,114.52 177.18,114.52 177.52,114.19 177.52,114.17 177.56,114.02 177.65,113.9 177.65,113.32 177.64,113.22 177.67,113.11 177.67,112.84 177.48,112.66 175.99,112.66 175.87,112.53 175.73,112.42 175.66,112.26 175.64,112.23 175.61,112.22 175.2,112.22 175.13,112.3 175.13,112.84 175.31,113.03 175.64,113.03 175.9,113.29 175.9,113.8 175.81,113.89 174.88,113.89 174.74,114.02 174.74,114.95 174.95,115.16 175.54,115.16
+3VGS on TOP (solid shape): outline of 1106 points within 175.22,94.55 187.67,106.29
+3VGS on BOTTOM (solid shape): 176.56,114.99 176.59,114.99 176.61,114.96 176.71,114.82 176.86,114.73 176.88,114.73 177.24,114.37 177.24,114.03 177.24,114.01 177.22,113.99 177.11,113.83 177.08,113.64 177.08,113.62 177.07,113.6 176.91,113.43 175.1,113.43 174.95,113.59 174.95,114.8 175.14,114.99
+3VGS on BOTTOM (solid shape): outline of 128 points within 179.51,91.01 188.27,96.94
+3VLP on BOTTOM (solid shape): 201.07,13.92 201.07,12.9 200.94,12.77 200.56,12.77 200.5,12.71 200.5,12.2 200.56,12.14 201.01,12.14 201.13,12.01 201.13,11.76 200.94,11.57 200.5,11.57 199.61,12.46 199.61,14.04 199.8,14.23 200.75,14.23
+3VS on TOP (solid shape): 56.1,40.02 56.1,37.48 55.97,37.35 54.64,37.35 54.51,37.48 54.51,40.08 54.7,40.27 55.85,40.27
+3VS on TOP (solid shape): 67.47,16.46 67.47,15.25 66.89,14.68 63.08,14.68 62.77,15 62.77,16.39 63.02,16.65 67.28,16.65
+3VS on TOP (solid shape): 185.39,91.39 185.39,89.1 185.2,88.91 184.12,88.91 183.86,89.16 183.86,91.45 183.99,91.58 185.2,91.58
+3VS on TOP (solid shape): 179.61,19.44 179.61,17.75 179.51,17.65 177.82,17.65 177.58,17.88 177.58,19.18 178.06,19.66 179.39,19.66
+3VS on TOP (solid shape): 66.69,110.89 66.69,109.48 67.6,108.58 67.6,108.12 67.5,108.02 65.98,108.02 65.84,108.15 65.84,110.91 65.95,111.03 66.55,111.03
+3VS on TOP (solid shape): 219.35,53.23 227.81,53.23 228.22,52.81 228.22,50.68 227.92,50.37 218.38,50.37 218.06,50.69 218.06,53.36 218.23,53.54 219.03,53.54
+3VS on TOP (solid shape): 177.89,55.62 178.37,55.62 178.41,55.58 178.41,53.84 178.26,53.69 178.05,53.69 178.04,53.7 177.18,53.7 176.63,54.24 176.63,55.79 176.87,56.03 177.48,56.03
+3VS on TOP (solid shape): 103.83,70.99 103.83,70.39 103.9,70.32 104.18,70.32 104.36,70.13 104.36,69.4 104.18,69.22 102.87,69.22 101.92,70.16 101.1,70.16 101.04,70.22 101.04,70.97 101.17,71.1 103.71,71.1
+3VS on TOP (solid shape): 56.73,19.12 56.73,17.35 56.23,16.84 54.89,16.84 54.45,16.39 54.45,15.76 54.32,15.63 53.62,15.63 53.53,15.73 53.53,17.01 53.41,17.13 51.26,17.13 51.03,17.36 51.03,18.97 51.88,19.82 56.04,19.82
+3VS on TOP (solid shape): 102.72,149.51 104.45,149.51 104.59,149.37 104.59,148.43 104.49,148.34 101.9,148.34 101.31,147.75 98.79,147.75 98.45,147.41 98.45,146.77 100.49,144.73 100.73,144.73 101.39,144.07 101.39,143.64 101.32,143.57 100.25,143.57 97.77,146.05 96.32,146.05 95.51,146.86 95.51,149.13 95.6,149.22 95.8,149.22 95.8,149.21 95.91,149.2 96.02,149.21 96.03,149.22 98.69,149.22 99.96,150.49 101.74,150.49
+3VS on TOP (solid shape): 217.96,175.21 217.96,172.66 218.48,172.14 218.48,170.94 218.33,170.79 218.33,169.95 218.88,169.39 218.88,169.14 218.87,169.1 218.83,169.09 218.51,168.85 218.61,168.46 218.65,168.39 218.63,168.32 218.55,168.13 218.59,167.92 218.59,167.06 218.53,167.01 218.53,166.6 218.47,166.53 217.6,166.53 217.51,166.62 217.51,167.21 217.78,167.48 217.79,167.48 217.95,167.64 218.01,167.86 218.01,168.29 218,168.39 217.97,168.48 217.96,168.49 217.96,168.84 218.03,168.91 218.05,168.92 218.35,169.34 217.92,169.62 217.84,169.63 217.8,169.69 217.61,169.92 217.3,169.93 217.13,169.76 217.11,169.52 217.08,169.44 217.01,169.4 216.27,169.4 215.35,170.32 215.35,171.52 215.61,171.78 215.61,172.95 215.83,173.17 216.13,173.17 216.44,173.49 216.44,174 216.66,174.22 216.66,175.17 216.88,175.4 217.77,175.4
+3VS on TOP (solid shape): outline of 392 points within 180.01,64.44 182.85,72.72
+3VS on TOP (solid shape): outline of 3131 points within 120.05,112.55 148.66,150.09
+3VS on BOTTOM (solid shape): 17.93,118.4 17.93,116.9 17.8,116.77 16.73,116.77 16.67,116.84 16.67,118.48 16.75,118.56 17.77,118.56
+3VS on BOTTOM (solid shape): 26.19,114.3 26.19,112.9 26.06,112.77 24.6,112.77 24.22,113.16 24.22,114.62 24.54,114.93 25.56,114.93
+3VS on BOTTOM (solid shape): 20.73,115 20.73,113.35 20.54,113.16 19.4,113.16 19.27,113.28 19.27,115 19.52,115.25 20.48,115.25
+3VS on BOTTOM (solid shape): 187.19,93.07 187.19,91.57 186.3,90.68 184.81,90.68 184.5,90.37 183.16,90.37 182.93,90.6 182.93,91.88 183.16,92.11 184.47,92.11 185.71,93.35 186.91,93.35
+3VS on BOTTOM (solid shape): 128.13,132.78 128.13,131.54 128.03,131.44 126.4,131.44 126.32,131.52 126.32,132.35 126.5,132.52 126.5,132.95 126.62,133.07 127.83,133.07
+3VS on BOTTOM (solid shape): 70.58,108.62 70.58,107.58 70.37,107.37 65.8,107.37 65.58,107.59 65.58,108.46 65.67,108.56 67.62,108.56 68.01,108.17 68.76,108.17 68.88,108.29 69.27,108.68 70.52,108.68
+3VS on BOTTOM (solid shape): 85.04,137.51 85.04,136.43 84.92,136.31 84.92,135.71 84.54,135.33 83.67,135.33 83.53,135.48 83.53,136.74 83.58,136.79 84.09,136.79 84.28,136.98 84.28,137.57 84.29,137.58 84.98,137.58
+3VS on BOTTOM (solid shape): 103.79,72.34 103.79,70.5 104,70.29 104.09,70.29 104.13,70.28 104.31,70.1 104.31,69.26 104.28,69.23 103.67,69.23 103.24,69.66 103.24,70.15 103.39,70.29 103.39,72.3 103.51,72.42 103.71,72.42
+3VS on BOTTOM (solid shape): 217.86,175.21 217.86,174.42 217.74,174.3 217.19,174.3 217.11,174.21 217.11,172.86 217.02,172.78 216.87,172.78 216.76,172.88 216.76,174.01 216.77,174.02 216.77,174.24 216.7,174.31 216.7,175.15 216.88,175.33 217.73,175.33
+3VS on BOTTOM (solid shape): 202.46,166.58 202.46,166.16 202.45,166.1 202.46,166.04 202.46,164.32 202.19,164.05 201.14,164.05 201.06,164.13 201.06,164.93 201.28,165.14 201.37,165.14 201.48,165.25 201.48,166.46 201.65,166.63 202.41,166.63
+3VS on BOTTOM (solid shape): 140.49,116.19 140.49,115.65 140.55,115.59 140.55,114.82 140.81,114.56 141.76,114.56 141.95,114.37 141.95,113.8 141.85,113.7 141.09,113.7 140.11,114.68 139.94,114.68 139.79,114.83 139.79,116.22 139.79,116.22 139.87,116.29 140.39,116.29
+3VS on BOTTOM (solid shape): 139.09,124.03 144.05,124.03 144.36,123.71 144.36,119.58 144.14,119.36 143.42,119.36 143.22,119.56 143.22,120.47 143.31,120.56 143.31,120.56 143.55,120.72 143.49,120.99 143.46,121.07 143.57,121.32 143.49,121.5 143.49,121.55 143.37,121.67 142.77,121.67 142.65,121.79 142.65,122.57 142.3,122.91 139.76,122.91 139.48,122.63 139.48,120.47 139.25,120.25 137.92,120.25 137.8,120.12 137.77,120.09 137.38,119.7 137.37,119.69 137.18,119.37 137.41,119.07 137.44,119.06 137.44,118.18 137.38,118.12 136.05,118.12 135.97,118.19 135.97,119.64 136.36,120.03 136.36,121.3 135.96,121.69 135.96,122.55 136.35,122.93 136.35,125.18 136.34,125.18 135.92,125.6 135.92,126.13 136.03,126.24 136.88,126.24
+3VS on BOTTOM (solid shape): outline of 342 points within 31.17,22.84 93.38,40.14
+3VS on IN1 (solid shape): 56.16,17.73 56.16,16.46 56.04,16.33 53.88,16.33 53.5,16.71 53.5,17.79 53.69,17.98 55.91,17.98
+3VS on IN1 (solid shape): 67.15,16.77 67.15,15.5 67.08,15.44 65.18,15.44 64.93,15.69 64.93,16.9 65.05,17.03 66.89,17.03
+3VS on IN1 (solid shape): outline of 132 points within 13.55,95.84 26.42,100.42
+3VS on IN1 (solid shape): outline of 149 points within 15.13,113 19.79,118.55
+3VS on IN2 (solid shape): 105.55,70.6 105.55,69.44 105.3,69.19 103.14,69.19 102.89,69.44 102.89,70.68 103.11,70.9 105.25,70.9
+3VS on IN2 (solid shape): 110.36,53.47 110.36,51.3 110.12,51.06 108.88,51.06 108.65,51.28 108.65,53.41 108.96,53.71 110.12,53.71
+3VS on IN2 (solid shape): 20.35,113.85 26.06,113.85 26.25,113.66 26.25,112.9 26.13,112.77 19.97,112.77 19.21,113.54 19.21,114.36 19.33,114.49 19.71,114.49
+3VS on IN2 (solid shape): 221.45,143.71 221.45,142 221.26,141.81 220.5,141.81 220.12,141.42 220.12,140.47 219.87,140.22 218.66,140.22 218.09,140.79 218.09,142.71 218.24,142.93 218.19,143.27 218.24,143.33 218.39,143.55 218.37,143.81 218.35,143.85 218.47,143.96 221.2,143.96
+3VS on IN2 (solid shape): 214.28,100.15 214.28,96.53 213.2,95.45 211.29,95.45 211.04,95.7 211.04,98.46 211.51,98.46 211.51,98.41 211.52,98.36 211.53,98.3 211.56,98.26 211.59,98.21 211.62,98.17 211.66,98.14 211.71,98.11 211.76,98.09 211.81,98.08 211.87,98.08 211.92,98.08 211.97,98.09 212.02,98.11 212.07,98.14 212.11,98.17 212.14,98.21 212.17,98.26 212.2,98.3 212.21,98.36 212.22,98.41 212.22,98.46 212.21,98.51 212.2,98.57 212.17,98.61 212.14,98.66 212.11,98.7 212.07,98.73 212.02,98.76 211.97,98.78 211.92,98.79 211.87,98.79 211.81,98.79 211.76,98.78 211.71,98.76 211.66,98.73 211.62,98.7 211.59,98.66 211.56,98.61 211.53,98.57 211.52,98.51 211.51,98.46 211.04,98.46 211.04,99.96 211.61,100.53 213.9,100.53
+3VS on IN2 (solid shape): outline of 557 points within 176.58,54.02 184.37,71.63
+3VS on IN3 (solid shape): outline of 87 points within 177.19,18.87 228.31,53.18
+3VS on TOP: 30.34,95.51 30.17,95.69 29.28,95.69 29.21,95.63 29.21,94.52 29.35,94.38 33.93,94.38 34.12,94.58 34.12,95.43 34.04,95.51
+3VS on VCC: 184.79,37.92 183.78,38.94 176.16,38.94 175.39,39.7 172.52,39.7 171.76,38.94 48.01,38.94 36.35,50.6 36.35,63.04 32.99,66.41 32.99,96.44 32.27,97.17 22,97.17 22,119.13 23.65,119.13 24.69,119.38 25.5,120.1 27.27,120.79 28.61,119.45 29.4,118.14 30.84,117.63 37,117.63 38.3,118.04 39.14,119.13 48,119.13 64.58,122.91 77.89,133.5 79.18,133.61 80.2,134.41 82.5,138.03 84.4,141.87 84.55,143.16 83.97,144.32 85.69,150.76 86.27,157.4 86.27,158.53 88.66,158.53 88.66,153.52 89.47,151.56 91.43,150.75 118.73,150.75 120.69,151.56 121.5,153.52 121.5,158.53 124.5,158.53 126.11,159.19 126.77,160.8 126.77,188.83 133.8,188.83 134.87,189.09 135.68,189.83 159.42,189.83 160.23,189.09 161.3,188.83 197.13,188.83 197.13,182.1 197.79,180.49 199.4,179.83 201.06,179.83 201.89,178.74 203.2,178.33 225.2,178.33 226.51,178.74 227.34,179.83 229.13,179.83 229.13,121.42 220.33,121.42 219.36,120.45 219.36,114.9 221.77,112.49 221.77,89.14 219.74,87.11 219.74,43.04 216.14,39.44 194.93,39.44 194.42,38.94 186.68,38.94 185.66,37.92 ; 1 cut-out
+3VS_6511 on BOTTOM (solid shape): 20.92,112.71 24.1,112.71 24.29,112.52 24.29,111.5 24.03,111.25 23.78,111.25 23.75,111.22 23.62,111.22 22.89,111.95 19.59,111.95 19.21,112.33 19.21,112.84 19.4,113.03 20.6,113.03
+3VS_RT on IN1 (solid shape): outline of 543 points within 193.14,158.11 213.78,173.97
+5V_HDD on TOP (solid shape): 226.75,62.13 227.22,62.12 227.49,62.13 228.03,61.58 228.03,58.79 227.66,58.42 226.03,58.42 224.49,59.95 218.25,59.95 218.09,60.12 218.09,63.22 218.3,63.43 225.44,63.43
+5V_USB_PWR1 on TOP (solid shape): 20.02,66.07 20.02,63.2 20.29,62.94 21.9,62.94 21.99,62.85 21.99,61.35 21.75,61.11 18.93,61.11 18.27,61.77 18.27,66.01 18.43,66.18 19.92,66.18
+5V_USB_PWR1 on BOTTOM (solid shape): 15.62,67.7 17.64,66.61 19.92,66.43 19.93,66.43 21.08,66.43 21.43,65.99 21.77,66.43 23.97,66.43 24.67,65.73 24.67,63.7 24.35,63.38 21.56,63.38 21.3,63.64 16.79,63.64 14.95,65.48 14.32,65.48 13.16,66.63 12.49,66.63 12.05,67.08 11.97,67.08 11.97,67.32 12.35,67.7
+5V_USB_PWR2 on TOP (solid shape): 25.05,53.41 25.05,50.75 24.86,50.56 22.44,50.56 22,51 22,53.29 22.32,53.6 24.86,53.6
+5V_USB_PWR2 on BOTTOM (solid shape): 25.56,53.1 25.56,49.98 24.92,49.35 19.38,49.35 18.99,49.75 16.56,49.75 15.83,49.02 15.32,49.02 15.14,48.84 12.54,48.84 12.1,49.29 12.1,51.38 14.19,53.48 25.18,53.48
+5V_USB_PWR3 on TOP (solid shape): 16.86,32.27 16.86,30.68 16.6,30.43 13.94,30.43 13.75,30.62 13.75,31.95 14.25,32.46 16.67,32.46
+5V_USB_PWR3 on BOTTOM (solid shape): outline of 116 points within 9.44,29.28 23.52,33.16
+5V_USB_PWR4 on TOP (solid shape): 213.58,49.98 213.58,45.79 213.14,45.35 210.21,45.35 209.9,45.67 209.9,47.76 210.09,47.95 211.23,47.95 211.67,48.4 211.67,49.98 211.8,50.11 213.45,50.11
+5V_USB_PWR4 on TOP (solid shape): 204.91,47.88 205.68,47.88 205.72,47.88 205.76,47.89 207.04,47.89 207.44,47.49 207.44,45.65 206.94,45.16 205.13,45.16 204.63,45.67 204.63,47.76 204.75,47.89 204.9,47.89
+5V_USB_PWR4 on IN2 (solid shape): 208.88,47.83 208.88,46.49 208.5,46.11 205.01,46.11 204.63,46.49 204.63,48.27 204.88,48.52 208.18,48.52
+5V_USB_PWR4 on IN2 (solid shape): 213.33,49.86 213.33,47.89 212.94,47.51 210.53,47.51 210.15,47.89 210.15,49.73 210.47,50.05 213.14,50.05
+5VALW on TOP (solid shape): 30.89,54.43 31.4,54.43 31.53,54.3 31.53,53.73 31.21,53.41 31.21,52.27 30.95,52.02 29.87,52.02 29.37,52.52 27.84,52.52 27.72,52.65 27.72,53.41 27.91,53.6 29.3,53.6 29.56,53.86 29.56,54.68 29.68,54.81 30.51,54.81
+5VALW on TOP (solid shape): 23.71,33.79 23.71,29.6 23.46,29.35 21.94,29.35 21.56,29.73 21.56,31.19 21.3,31.44 19.65,31.44 19.59,31.51 19.59,32.27 19.78,32.46 21.11,32.46 21.87,33.22 21.87,33.92 22.13,34.17 23.33,34.17
+5VALW on TOP (solid shape): 167.35,19.76 167.35,10.68 166.84,10.17 164.3,10.17 163.61,10.87 163.61,18.49 162.27,19.82 159.67,19.82 159.01,20.48 159.01,22.45 159.18,22.62 159.68,23.12 163.99,23.12
+5VALW on TOP (solid shape): 207.36,42.81 207.36,41.29 207.8,40.84 208.44,40.84 208.63,40.65 208.63,40.14 208.88,39.89 208.88,38.43 208.82,38.36 206.34,38.36 206.09,38.11 206.09,33.03 205.83,32.78 204.63,32.78 204.25,33.16 204.25,39 206.34,41.09 206.34,42.81 206.47,42.94 207.23,42.94
+5VALW on TOP (solid shape): 28.35,64.91 28.35,64.18 28.13,63.97 28.13,59.04 27.99,58.9 26.56,58.9 26.48,58.98 26.48,61.62 26.23,61.87 24.64,61.87 24.58,61.94 24.58,62.82 24.71,62.95 26.17,62.95 26.47,63.26 26.47,64.69 26.81,65.03 28.22,65.03
+5VALW on BOTTOM (solid shape): 207.86,41.73 207.86,40.08 207.67,39.89 206.02,39.89 205.64,40.27 205.64,41.73 205.9,41.98 207.61,41.98
+5VALW on BOTTOM (solid shape): 116.36,12.64 117.07,12.64 117.07,13.15 117.56,13.15 117.56,12.64 118.27,12.64 118.27,13.15 121.63,13.15 121.63,12.64 122.34,12.64 122.34,13.15 122.83,13.15 122.83,12.64 123.54,12.64 123.54,13.15 124.3,13.15 124.43,13.03 124.43,10.23 124.17,9.98 115.28,9.98 115.09,10.17 115.09,12.96 115.28,13.15 116.36,13.15
+5VALW on BOTTOM (solid shape): 99.85,29.47 99.85,26.24 99.66,26.05 96.99,26.05 96.49,26.55 96.49,27.32 96.57,27.55 96.49,27.78 96.49,28.71 96.55,28.78 96.68,28.78 96.74,28.71 96.74,28.01 96.78,27.97 96.78,27.71 96.8,27.69 96.8,27.57 96.84,27.53 96.85,27.52 97.36,27.32 97.45,27.87 97.44,27.89 97.31,28.01 97.31,28.65 97.44,28.78 97.95,28.78 98.14,28.97 98.14,29.41 98.26,29.54 99.79,29.54
+5VALW on IN1 (solid shape): 104.22,26.19 106.9,26.19 120.57,12.52 124.04,12.52 125.76,10.81 131.09,10.81 131.66,11.38 147.54,11.38 147.86,11.06 147.86,10 147.6,9.75 116.01,9.75 114.65,11.11 114.65,14.46 106.03,23.07 99.66,23.07 97.37,25.36 97.37,27.03 97.73,27.39 103.02,27.39
+5VALW on IN2 (solid shape): 125.63,10.93 131.28,10.93 131.73,11.38 147.54,11.38 147.86,11.06 147.86,10 147.6,9.75 115.38,9.75 114.65,10.49 114.65,11.76 115.41,12.52 124.04,12.52
+5VALW on IN3 (solid shape): outline of 379 points within 158.78,21.73 206.18,37.92
+5VALW on VCC: 166.67,1.27 166.67,7.48 166.01,9.09 164.4,9.75 90.67,9.75 90.67,11.48 90.01,13.09 88.4,13.75 62.4,13.75 60.79,13.09 60.13,11.48 60.13,10.25 56.4,10.25 55.73,10.12 55.17,9.75 50.63,9.75 50.07,10.12 49.4,10.25 47.4,10.25 46.73,10.12 46.17,9.75 41.63,9.75 41.07,10.12 40.4,10.25 38.4,10.25 37.73,10.12 37.17,9.75 32.63,9.75 32.07,10.12 31.4,10.25 27.84,10.25 27.84,12.56 27.31,13.09 26.3,13.09 25.68,13.7 25.68,15.27 26.57,16.16 26.57,18.4 26.3,18.68 25.2,18.68 24.86,18.34 24.86,17.39 24.75,17.28 20.64,17.28 20.48,17.45 20.48,19.02 20.64,19.19 24.71,19.19 25.05,19.53 25.05,22.68 29.47,22.68 29.79,23 31.53,23 31.53,28.27 23.55,28.27 21.7,26.43 21.05,26.43 21.05,63.57 29.71,63.57 30.32,62.96 30.32,55.09 30.76,54.64 30.76,42.01 38.76,34 38.76,20.42 40.25,18.93 119.62,18.93 124.38,14.17 129.4,14.17 132.64,10.93 142.18,10.93 145.42,14.17 155.65,14.17 158.12,16.65 168.26,16.65 176.58,8.33 207.19,8.33 208.82,6.7 208.82,1.27
+5VALWP on BOTTOM (solid shape): outline of 213 points within 115.02,12.77 124.3,27.59
+5VS on TOP (solid shape): 38.51,12.01 38.51,10.36 38.45,10.3 37.49,10.3 36.61,11.19 36.61,12.84 36.8,13.03 37.49,13.03
+5VS on TOP (solid shape): 43.08,31.25 43.08,29.79 42.76,29.47 41.69,29.47 41.56,29.6 41.56,31.25 41.69,31.38 42.96,31.38
+5VS on TOP (solid shape): 46.88,102.46 46.88,101.64 46.79,101.55 44.63,101.55 44.44,101.75 44.44,102.46 44.6,102.63 46.72,102.63
+5VS on TOP (solid shape): 32.79,96.96 32.79,96.2 32.6,96.01 29.3,96.01 29.24,96.07 29.24,96.96 29.3,97.03 32.73,97.03
+5VS on TOP (solid shape): 33.37,13.09 33.37,12.08 33.49,11.95 33.49,11.76 33.37,11.63 32.54,11.63 32.41,11.76 32.41,13.09 32.54,13.22 33.24,13.22
+5VS on TOP (solid shape): 20.22,26.05 20.22,25.47 20.1,25.35 19.98,25.35 19.27,25.35 19.21,25.35 19.08,25.22 18.25,25.22 18,25.47 18,25.73 18.19,25.92 19.14,25.92 19.33,26.11 20.16,26.11
+5VS on TOP (solid shape): 218.58,59.59 218.58,59.2 218.63,59.15 219.96,59.15 219.99,59.19 219.99,59.51 219.98,59.52 219.98,59.65 220.06,59.73 224.11,59.73 224.32,59.51 224.32,55.48 223.92,55.08 218.34,55.08 217.59,55.83 217.59,59.29 218.02,59.73 218.44,59.73
+5VS on BOTTOM (solid shape): 13.61,119.24 13.61,117.88 13.45,117.72 12.19,117.72 11.92,118 11.92,119.25 12.06,119.39 13.46,119.39
+5VS on BOTTOM (solid shape): 47.85,104.19 47.85,102 47.65,101.8 44.31,101.8 44.11,102.01 44.11,104.14 44.36,104.39 47.66,104.39
+5VS on BOTTOM (solid shape): 89.5,132.22 89.5,131.31 89.15,130.96 88.58,130.96 88.29,131.25 88.29,132.22 88.42,132.34 89.37,132.34
+5VS on BOTTOM (solid shape): 104.74,32.59 104.74,30.81 104.49,30.55 101.57,30.55 101.38,30.36 100.49,30.36 100.42,30.43 100.42,31.05 99.84,31.05 99.84,31.3 100.39,31.3 100.39,31.84 99.84,31.84 99.84,32.1 100.36,32.1 100.36,32.1 100.42,32.1 100.42,32.78 100.87,33.22 104.11,33.22
+5VS on BOTTOM (solid shape): 222.13,121.68 222.13,118.1 221.58,117.55 221.04,117.55 220.41,116.91 220.41,116.36 220.95,116.36 220.95,116.11 220.4,116.11 220.4,115.56 220.95,115.56 220.95,115.31 220.4,115.31 220.4,114.82 219.46,114.82 219.11,115.18 219.11,118.4 219.12,118.42 219.12,120.93 220.02,121.83 221.97,121.83
+5VS on IN1 (solid shape): 33.43,11.95 33.43,10.81 33.3,10.68 32.54,10.68 32.41,10.81 32.41,12.08 32.48,12.14 33.24,12.14
+5VS on IN1 (solid shape): 38.45,11.63 38.45,10.74 38.26,10.55 36.92,10.55 36.73,10.74 36.73,11.44 37.05,11.76 38.32,11.76
+5VS on IN1 (solid shape): 19.59,26.66 19.59,25.83 19.09,25.33 18.16,25.33 18.02,25.47 18.02,25.78 18.48,26.24 18.48,26.83 18.52,26.87 19.37,26.87
+5VS on IN1 (solid shape): 43.02,31.32 43.02,30.55 42.86,30.39 42.29,30.39 42.26,30.36 40.8,30.36 40.73,30.43 40.73,31.19 40.99,31.44 42.89,31.44
+5VS on IN1 (solid shape): 222.47,156.47 222.47,154.44 219.99,151.97 219.99,122.49 220.83,121.66 220.83,117.14 220.63,116.94 220.09,116.94 218.09,118.95 218.09,133.26 218.09,133.27 218.09,133.58 218.09,133.59 218.09,137.33 218.09,137.34 218.09,137.64 218.09,137.65 218.09,142.71 218.25,142.94 218.19,143.21 218.18,143.29 218.22,143.35 218.38,143.7 218.12,143.99 218.09,144 218.09,152.92 220.31,155.14 220.31,156.22 221.07,156.98 221.96,156.98
+5VS on IN2 (solid shape): 31.33,97.03 31.33,96.33 31.14,96.14 28.98,96.14 28.98,96.84 29.3,97.15 31.21,97.15
+5VS on IN2 (solid shape): 13.35,119.25 13.35,117.85 13.26,117.76 12.27,117.76 12.15,117.88 12.15,119.26 12.25,119.36 13.24,119.36
+5VS on IN3 (solid shape): 46.92,103.45 46.92,101.86 46.78,101.72 45.69,101.72 45.52,101.89 45.52,103.47 45.69,103.64 46.73,103.64
+5VS on VCC: 209.33,1.27 209.33,6.91 207.65,8.58 207.8,8.73 207.8,20.82 205.75,22.87 179.08,22.87 173.04,28.9 98.68,28.78 97.35,30.05 93.52,30.05 92.32,28.84 39.27,28.9 39.27,34.21 31.27,42.22 31.27,54.85 30.83,55.3 30.83,63.17 29.92,64.08 21.05,64.08 21.05,75.94 25.66,75.94 26.7,76.98 26.7,94.53 25.47,95.76 22,95.76 22,96.66 32.05,96.66 32.48,96.23 32.48,66.2 35.84,62.83 35.84,50.39 47.8,38.43 171.97,38.43 172.73,39.19 175.18,39.19 175.95,38.43 183.57,38.43 184.58,37.41 185.87,37.41 186.89,38.43 194.63,38.43 195.14,38.94 216.35,38.94 220.25,42.83 220.25,86.9 222.28,88.93 222.28,112.7 219.87,115.11 219.87,120.24 220.54,120.91 229.13,120.91 229.13,1.27
+5VS_CRT on BOTTOM (solid shape): 11.63,117.64 11.63,115.75 12.38,115 13.94,115 13.94,113.79 12.92,113.79 12.92,113.78 12.92,112.51 12.42,112.01 11.63,112.01 11.46,112.18 11.46,112.96 11.27,113.16 11.27,113.78 11.27,113.79 10.08,113.79 9.89,113.98 9.89,117.7 10.04,117.85 11.41,117.85
+5VS_CRT on IN2 (solid shape): 12.73,114.74 12.73,112.86 14.28,111.31 14.28,108.83 14.18,108.58 14.28,108.33 14.28,107.43 14.02,107.17 13.66,107.17 13.33,107.49 13.33,108.06 13.39,108.25 13.33,108.45 13.33,110.39 11.52,112.2 11.52,113.92 10.51,114.93 10.51,115.75 10.7,115.94 11.53,115.94
+5VS_ODD on BOTTOM (solid shape): 224.72,119.16 224.72,115.7 225.84,114.58 226.5,114.58 227.72,113.35 227.72,112.79 227.44,112.51 226.79,112.51 226.02,113.28 225.41,113.28 224.6,112.46 224.6,110.85 224.18,110.44 222.6,110.44 222.53,110.5 222.53,111.9 222.81,112.17 222.81,113.86 222.8,113.86 222.65,114.02 220.92,114.02 220.54,114.4 220.54,115.15 220.57,115.18 221.08,115.18 221.11,115.21 221.11,115.69 221.08,115.72 220.56,115.72 220.55,115.73 220.55,115.95 220.56,115.96 221.03,115.96 221.09,115.96 221.11,115.98 221.11,116.5 221.09,116.52 220.55,116.52 220.55,116.85 221.12,117.42 221.91,117.42 222.57,118.08 222.57,119.25 222.75,119.42 224.45,119.42
+5VS_TOUCH on TOP (solid shape): 25.61,96.9 27.66,96.9 27.82,97.05 28.53,97.05 28.58,97 28.58,94.74 28.53,94.69 27.87,94.69 27.79,94.77 27.79,95.74 27.65,95.88 23.7,95.88 23.44,96.14 23.44,97.23 23.62,97.41 25.1,97.41
+DVCC33 on TOP (solid shape): 199.29,177.05 199.29,174.76 199.04,174.51 197.7,174.51 197.58,174.64 197.58,177.05 197.7,177.18 199.17,177.18
+DVCC33 on TOP (solid shape): 204.28,166.1 204.56,165.95 204.85,166.08 204.86,166.1 204.91,166.1 205.25,165.76 205.33,165.76 205.76,165.6 205.99,165.99 206.02,166.07 206.1,166.1 207.27,166.1 207.41,165.96 207.41,162.35 207.32,162.25 205.1,162.25 204.94,162.09 204.94,161.41 204.89,161.35 204.18,161.35 204.1,161.43 204.1,162.46 204.36,162.71 204.36,163.27 204.48,163.4 205.56,163.4 206.25,164.09 206.25,164.76 206.21,164.8 204.88,164.8 204.66,165.02 203.56,165.02 203.39,165.19 203.39,165.36 203.39,165.37 203.47,165.54 203.48,165.73 203.48,165.75 203.83,166.1
+DVCC33 on IN3 (solid shape): outline of 711 points within 196.37,163.27 207.8,174.64
+VCC_PWR_SRC on TOP (solid shape): 118.02,142.33 117.82,142.12 116.74,142.12 116.29,142.58 116.29,143.53 116.41,143.66 118.02,143.66
+VCC_PWR_SRC on BOTTOM (solid shape): 137.95,147.71 137.95,142.19 137.51,141.74 127.08,141.74 126.66,142.16 124.96,142.16 124.3,142.82 120.59,142.82 120.23,142.47 120.23,142 118.95,140.71 114.96,140.71 114.91,140.76 114.91,143.3 114.75,143.46 114.1,143.46 113.96,143.6 113.96,144.42 114.01,144.47 116.23,144.47 116.3,144.4 116.3,143.88 116.51,143.67 118.8,143.67 120.35,145.22 122.36,145.22 122.84,145.71 122.84,146.5 125,148.66 137,148.66
+VDD_MEM15_REFDA on IN3 (solid shape): outline of 336 points within 172.82,124.49 181.28,127.41
+VDD_MEM15_REFDB on IN3 (solid shape): outline of 739 points within 183.63,102.82 195.96,120.63
+VDDCI on TOP (solid shape): outline of 973 points within 176.55,107.02 186.28,126.86
+VDDCI on BOTTOM (solid shape): 195.93,182.89 195.93,179.78 195.16,179.02 193.01,179.02 192.69,179.33 192.69,179.34 192.62,179.4 192.62,180.42 193.15,180.42 193.15,181.12 192.62,181.12 192.62,181.62 193.15,181.62 193.15,182.32 192.62,182.32 192.62,183.78 192.88,184.03 194.78,184.03
+VDDCI on BOTTOM (solid shape): outline of 300 points within 176.19,114.9 186.24,126.03
+VDDCI on IN1 (solid shape): outline of 592 points within 176.62,114.68 186.42,125.8
+VDDCI on VCC: 183.52,112.34 182.59,113.27 182.59,121.84 181.93,122.5 165.42,122.5 156.75,131.18 156.75,164.88 160.92,169.05 182.89,169.05 184.94,171.1 184.94,180.69 187.08,182.83 194.74,182.83 195.04,182.53 195.04,178.85 195.99,177.9 195.99,162.51 181.66,162.51 179.57,160.41 167.37,160.41 161.51,154.55 161.51,137.95 172.9,126.57 182.61,126.57 183.76,125.42 184.84,125.42 185.7,124.56 185.7,112.34
+VDDCIP on BOTTOM (solid shape): 192.5,185.32 192.5,182.2 193.01,182.2 193.01,181.75 192.5,181.75 192.5,181 193.01,181 193.01,180.55 192.47,180.55 192.47,178.37 191.51,177.4 191.51,176.6 191.44,176.54 187.99,176.54 187.67,176.86 187.67,185.43 187.99,185.75 192.07,185.75
+VDDR4 on TOP (solid shape): 186.55,114.96 186.55,114.95 186.63,114.83 186.75,114.75 186.84,114.72 186.91,114.66 186.91,113.48 186.84,113.41 186.27,113.41 186,113.69 185.07,113.69 184.68,114.08 184.68,115.27 184.85,115.44 186.07,115.44
+VDDR4 on BOTTOM (solid shape): 186.08,115.64 186.09,115.63 186.16,115.46 186.31,115.34 186.32,115.34 186.52,115.14 186.52,115.11 186.57,114.91 186.72,114.76 186.73,114.76 186.75,114.73 186.75,113.63 186.63,113.51 186.23,113.51 185.84,113.91 185.73,113.91 185.71,113.91 185.7,113.92 185.46,114.02 185.23,113.92 185.2,113.91 185.16,113.91 184.63,113.38 183.33,113.38 183.31,113.38 183.3,113.39 183.21,113.46 183.11,113.49 183.11,113.5 183.11,113.75 183.12,113.77 183.13,113.79 183.15,113.81 183.16,113.81 183.5,114.19 183.16,114.57 183.13,114.59 183.11,114.62 183.11,114.82 183.13,114.84 183.14,114.85 183.26,114.95 183.34,115.08 183.35,115.11 183.38,115.12 183.62,115.12 183.63,115.11 183.63,115.08 183.99,114.82 184.34,115.09 184.35,115.11 184.56,115.32 184.57,115.32 184.73,115.42 184.83,115.58 184.83,115.59 185.09,115.85 185.11,115.86 185.2,115.9 185.28,115.95 185.77,115.95
GND on TOP (solid shape): 24.48,76.77 24.48,75.63 24.29,75.44 22.44,75.44 22.13,75.75 22.13,77.09 24.16,77.09
GND on TOP (solid shape): 26.24,61.49 26.24,60.16 26.12,60.03 24.78,60.03 24.59,60.22 24.59,61.55 24.72,61.68 26.05,61.68
GND on TOP (solid shape): 35.53,79.69 35.53,78.04 35.33,77.85 34.64,77.85 34.51,77.98 34.51,79.69 34.57,79.75 35.46,79.75
GND on TOP (solid shape): 37.75,114.55 37.75,112.84 37.43,112.52 36.03,112.52 35.84,112.71 35.84,114.62 35.97,114.74 37.56,114.74
GND on TOP (solid shape): 99.79,136.47 99.79,134.69 99.66,134.57 98.39,134.57 98.26,134.69 98.26,136.47 98.39,136.6 99.66,136.6
GND on TOP (solid shape): 103.15,138.76 103.15,134.82 102.9,134.57 101.82,134.57 101.63,134.76 101.63,138.82 101.69,138.88 103.03,138.88
GND on TOP (solid shape): 104.35,65.95 104.35,62.59 104.25,62.49 102.8,62.49 102.22,63.07 102.22,65.99 102.45,66.22 104.08,66.22
GND on TOP (solid shape): 106.46,138.63 106.46,134.76 106.26,134.57 105.12,134.57 104.93,134.76 104.93,138.76 105.06,138.88 106.2,138.88
GND on TOP (solid shape): 109.82,138.63 109.82,134.82 109.63,134.63 108.49,134.63 108.3,134.82 108.3,138.5 108.61,138.82 109.63,138.82
GND on TOP (solid shape): 113.12,26.55 113.12,23.95 112.93,23.76 108.42,23.76 107.92,24.27 107.92,26.62 108.17,26.87 112.81,26.87
GND on TOP (solid shape): 113.19,138.63 113.19,134.88 112.93,134.63 111.85,134.63 111.66,134.82 111.66,138.69 111.73,138.76 113.06,138.76
GND on TOP (solid shape): 118.9,145.17 118.9,144.03 118.71,143.84 116.62,143.84 116.17,144.28 116.17,145.3 116.23,145.36 118.71,145.36
GND on TOP (solid shape): 130.3,176.76 130.3,174.69 130.1,174.49 129.44,174.49 129.33,174.59 129.33,176.84 129.44,176.95 130.11,176.95
GND on TOP (solid shape): 149.44,183.72 149.44,179.14 149.19,178.89 147.98,178.89 147.79,179.08 147.79,183.78 147.86,183.84 149.32,183.84
GND on TOP (solid shape): 158.55,158.88 158.55,156.16 158.2,155.81 155.53,155.81 155.21,156.13 155.21,158.8 155.48,159.06 158.37,159.06
GND on TOP (solid shape): 214.98,173.11 214.98,170.83 214.85,170.7 212.37,170.7 212.18,170.89 212.18,171.33 214.02,173.17 214.91,173.17
GND on TOP (solid shape): 220.69,98.82 220.69,95.77 220.37,95.45 219.23,95.45 219.14,95.55 219.14,98.91 219.17,98.94 220.56,98.94
GND on TOP (solid shape): 26.29,34.01 26.29,30.01 26.08,29.81 24.07,29.81 23.92,29.97 23.92,34.12 24.03,34.24 26.06,34.24
GND on TOP (solid shape): 144.21,30.34 144.21,28.57 144.52,28.25 144.52,26.86 144.27,26.61 143.32,26.61 143.01,26.93 143.01,30.6 143.21,30.81 143.73,30.81
GND on TOP (solid shape): 158.84,134.43 158.84,126.3 158.78,126.24 158.08,126.24 156.49,127.83 153.7,127.83 153.25,128.27 153.25,133.73 154.08,134.56 158.71,134.56
GND on TOP (solid shape): 161.38,83.3 161.38,78.56 160.94,78.12 157.95,78.12 157.76,78.31 157.76,84.39 157.89,84.52 160.16,84.52
GND on TOP (solid shape): 198.63,91.76 198.63,90.2 198.43,90 192.42,90 192.31,90.11 192.31,90.97 192.4,91.06 192.73,91.06 193.71,92.04 198.35,92.04
GND on TOP (solid shape): 199.86,72.02 199.86,70.12 199.62,69.88 193.18,69.88 192.75,70.31 192.75,71.89 192.94,72.08 199.8,72.08
GND on TOP (solid shape): 39.65,86.36 39.65,82.99 39.46,82.8 36.16,82.8 35.78,83.18 35.78,86.8 35.91,86.93 39.08,86.93
GND on TOP (solid shape): 148.11,145.43 148.11,143.77 147.92,143.58 140.36,143.58 140.11,143.84 140.11,145.23 140.3,145.43 140.81,145.43 141.19,145.81 147.73,145.81
GND on TOP (solid shape): 149.44,176.48 149.44,173.94 149,173.49 147.22,173.49 147.16,173.56 147.16,176.67 147.29,176.79 149.13,176.79
GND on TOP (solid shape): 29.87,64.63 29.87,58.98 29.77,58.88 28.34,58.88 28.31,58.92 28.31,63.89 28.55,64.14 28.55,64.76 28.67,64.88 29.62,64.88
GND on TOP (solid shape): 104.74,74.05 104.74,70.5 104.69,70.45 104.06,70.45 103.98,70.53 103.98,71.13 103.72,71.38 102.26,71.38 102.07,71.57 102.07,74.43 102.39,74.75 104.04,74.75
GND on TOP (solid shape): 160.72,176.67 161.76,176.67 161.89,176.54 161.89,175.97 161.7,175.78 158.67,175.78 158.44,176.01 158.44,177.77 158.54,177.86 159.53,177.86
GND on TOP (solid shape): 21.61,97.24 21.61,96.49 21.83,96.26 22.04,96.26 22.15,96.15 22.15,95.91 22.04,95.79 20.55,95.79 20.18,96.16 20.18,97.24 20.32,97.38 21.47,97.38
GND on TOP (solid shape): 68.42,77.99 68.42,73.84 68.14,73.55 67.54,73.55 66.51,72.52 63.71,72.52 63.47,72.77 63.47,77.86 63.85,78.24 68.16,78.24
GND on TOP (solid shape): 142.27,188.22 142.02,187.97 140.62,187.97 139.86,187.21 139.86,186.76 139.6,186.51 136.05,186.51 135.6,186.95 135.6,189.72 135.64,189.77 135.68,189.83 142.27,189.83
GND on TOP (solid shape): 167.67,172.29 167.67,171.97 167.61,171.9 167.61,170.7 167.54,170.63 167.42,170.63 167.35,170.7 167.35,171.78 167.16,171.97 167.16,172.03 166.84,172.35 166.84,172.67 166.97,172.79 167.16,172.79
GND on TOP (solid shape): 174.99,158.56 174.99,157.27 174.82,157.1 171.52,157.1 171.17,156.76 161.93,156.76 161.87,156.82 161.87,157.51 161.97,157.6 162.23,157.6 162.55,157.92 162.55,159.29 163.08,159.83 173.73,159.83
GND on TOP (solid shape): 182.44,158.66 182.44,157.95 182.34,157.85 181.44,157.85 181.08,157.49 181.08,157.16 180.8,156.89 177.76,156.89 177.61,157.04 177.61,158.03 177.98,158.4 180.36,158.4 180.75,158.78 182.32,158.78
GND on TOP (solid shape): 182.89,64.93 182.89,63.83 182.98,63.73 182.98,61.78 182.68,61.47 181.08,61.47 180.88,61.67 180.88,63.89 181.27,64.28 181.79,64.28 181.99,64.49 181.99,64.98 182.06,65.04 182.78,65.04
GND on TOP (solid shape): 187.43,158.15 193.67,158.15 193.95,158.43 198.08,158.43 198.25,158.27 198.25,157.59 197.87,157.2 193.65,157.2 193.29,156.85 183.02,156.85 182.85,157.01 182.85,159.05 183.03,159.23 186.35,159.23
GND on TOP (solid shape): 91.47,139.2 91.47,136.22 91.22,135.96 88.48,135.96 88.17,135.65 88.17,135.14 88.1,135.07 87.6,135.07 87.47,135.2 87.47,138.25 87.15,138.57 85.5,138.57 85.37,138.69 85.37,139.14 85.56,139.33 91.34,139.33
GND on TOP (solid shape): 183.04,74.94 183.04,71.16 182.97,71.1 182.43,71.1 182.34,71.19 182.34,72.65 182.15,72.84 182.07,72.85 180.51,72.85 180.5,72.84 180.31,72.65 179.86,72.65 179.67,72.84 179.67,75.07 179.8,75.19 182.78,75.19
GND on TOP (solid shape): 191.99,186.32 191.99,185.3 191.48,184.8 191.48,176.92 191.55,176.86 191.55,175.97 190.78,175.21 187.86,175.21 186.91,176.16 184.88,176.16 184.51,176.53 178.71,176.53 178.27,176.97 178.27,182.13 178.97,182.83 183.67,182.83 187.54,186.7 191.61,186.7
GND on TOP (solid shape): 162.27,174.38 162.27,171.84 161.76,171.33 161.76,166.76 162.08,166.44 162.78,166.44 162.97,166.25 162.97,162.19 162.46,161.68 159.41,161.68 158.65,162.44 158.65,169.75 158.91,170 158.91,173.81 159.22,174.13 160.24,174.13 160.56,174.44 162.21,174.44
GND on TOP (solid shape): 12.35,56.06 12.35,53.41 11.91,52.98 10.49,52.98 10.4,53 10.3,53 0.31,53 0.27,53.02 0.25,53.05 0.25,56.55 0.27,56.58 0.31,56.6 11.81,56.6
GND on TOP (solid shape): 211.99,85.67 211.99,81.35 209.16,78.52 201.45,78.52 200.89,77.96 198.18,77.96 197.01,79.13 193.52,79.13 193.42,79.23 193.42,80.37 193.89,80.85 194.78,80.85 195.74,81.8 208.56,81.8 209.32,82.56 209.32,85.8 209.64,86.12 211.55,86.12
GND on TOP (solid shape): 130.91,166.62 130.91,165.8 131.05,165.66 131.05,164.14 130.92,164.01 129.86,164.01 129.74,163.89 129.74,163.54 129.59,163.39 128.3,163.39 128.12,163.57 128.12,163.8 127.93,163.99 127.42,163.99 127.18,164.23 127.18,164.81 127.22,164.85 127.83,164.85 128.17,165.19 128.76,165.19 129.08,165.5 129.08,166.42 129.37,166.71 130.81,166.71
GND on TOP (solid shape): 221.77,131.65 221.77,125.88 220.97,125.09 220.97,120.85 220.59,120.47 220.06,120.47 219.75,120.16 219.75,119 219.61,118.86 219.17,118.86 219.05,118.99 219.05,120.66 219.39,121 219.39,125.93 219.47,126.01 219.9,126.01 219.92,126.03 220.01,126.03 220.17,126.2 220.17,127.59 219.58,128.18 219.58,133.16 219.74,133.31 220.11,133.31
GND on TOP (solid shape): 182.02,175.46 183.59,175.46 184.18,174.87 184.18,174.87 184.18,174.13 184.05,174 183.23,174 182.97,173.75 182.97,172.48 181.77,171.27 181.77,170.76 181.7,170.7 181.19,170.7 181,170.89 181,172.54 180.75,172.79 179.42,172.79 179.16,173.05 179.16,174.44 179.35,174.64 179.92,174.64 180.05,174.76 180.05,176.22 180.15,176.32 181.16,176.32
GND on TOP (solid shape): 130.76,24.94 130.76,23.29 130.56,23.09 129.7,23.09 129.43,22.82 129.43,21.46 128.81,20.84 122.69,20.84 122.56,20.97 122.56,22.02 122.71,22.17 123.98,22.17 124.17,22.36 124.17,24.33 124.3,24.46 125.35,24.46 125.86,24.97 127.6,24.97 127.73,24.84 129.59,24.84 129.82,25.07 130.64,25.07
GND on TOP (solid shape): 207.29,60.78 207.29,58.56 207.42,58.43 208.06,58.43 208.12,58.37 208.12,57.8 208.06,57.73 207.42,57.73 207.06,57.38 207.06,54.9 206.98,54.81 202.47,54.81 201.96,54.3 201.26,54.3 201.2,54.37 201.2,55 201.13,55.06 200.56,55.06 200.44,55.19 200.44,55.76 200.5,55.83 201.9,55.83 202.09,55.64 202.53,55.64 203.87,56.98 203.87,57.62 204.58,58.33 205.9,58.33 206.22,58.65 206.22,60.72 206.34,60.84 207.23,60.84
GND on TOP (solid shape): 14.43,74.88 13.99,74.17 13.2,73.9 12.92,73.9 12.54,73.52 12.54,71 11.55,70.02 11.04,70.02 10.77,70.44 10.3,70.6 1.1,70.6 1.07,70.62 1.05,70.65 1.05,74.36 1.07,74.39 1.1,74.41 13.2,74.41 13.62,74.54 13.9,74.88
GND on TOP (solid shape): 11.78,95.26 11.78,92.15 12.22,91.7 13.2,91.7 13.92,91.48 14.38,90.88 13.81,90.88 13.54,91.11 13.2,91.19 0.91,91.19 0.87,91.21 0.85,91.24 0.85,95.04 0.85,95.66 1.69,95.66 2.58,96.03 2.94,96.91 2.94,98.37 3.14,98.56 8.47,98.56
GND on TOP (solid shape): outline of 87 points within 110.58,138.44 116.81,144.79
GND on TOP (solid shape): outline of 91 points within 213.01,61.19 218.12,74.79
GND on TOP (solid shape): 12.41,38.49 12.41,35.13 11.27,33.98 8.52,33.98 8.48,33.94 8.36,33.81 8.23,33.69 8.23,23.82 8.74,23.31 11.78,23.31 12.35,22.74 12.35,21.22 10.76,19.63 0.25,19.63 0.25,21.29 0.27,21.33 0.31,21.35 7.47,21.35 8.21,21.95 7.76,22.8 7.73,22.82 7.72,22.84 7.72,33.95 7.73,33.98 7.76,34 8.21,34.85 7.47,35.45 1.1,35.45 1.07,35.47 1.05,35.5 1.05,38.94 1.07,38.98 1.1,39 11.91,39
GND on TOP (solid shape): outline of 162 points within 216.12,99.88 221.33,116.91
GND on TOP (solid shape): outline of 183 points within 137.57,147.84 146.71,159.52
GND on TOP (solid shape): outline of 265 points within 112.98,93.71 114.63,102.6
GND on TOP (solid shape): outline of 87 points within 2.94,116.76 92.68,159.55
GND on TOP (solid shape): outline of 237 points within 16.62,0.25 230.15,190.85
GND on BOTTOM (solid shape): 113.55,28.81 113.55,27.47 110.44,27.47 110.44,28.74 110.63,28.93 113.42,28.93
GND on BOTTOM (solid shape): 109.82,134.44 109.82,132.66 109.69,132.53 109,132.53 108.74,132.79 108.74,134.63 109.63,134.63
GND on BOTTOM (solid shape): 30.99,53.25 30.99,50.97 30.64,50.62 27.66,50.62 27.43,50.86 27.43,53.13 27.84,53.54 30.7,53.54
GND on BOTTOM (solid shape): 37.82,114.54 37.82,112.3 37.66,112.14 36.29,112.14 35.91,112.52 35.91,114.55 36.1,114.74 37.62,114.74
GND on BOTTOM (solid shape): 91.36,29.99 91.36,29.05 91.31,28.99 88.58,28.99 88.37,29.2 88.37,29.76 88.82,30.22 91.14,30.22
GND on BOTTOM (solid shape): 93.03,29.39 93.03,27.45 92.9,27.32 91.84,27.32 91.76,27.41 91.76,29.45 91.81,29.5 92.92,29.5
GND on BOTTOM (solid shape): 101.31,29.47 101.31,27.32 101.25,27.25 100.23,27.25 99.98,27.51 99.98,29.35 100.17,29.54 101.25,29.54
GND on BOTTOM (solid shape): 104.55,30.17 104.55,28.9 104.36,28.71 102.01,28.71 101.82,28.9 101.82,30.24 101.95,30.36 104.36,30.36
GND on BOTTOM (solid shape): 131.03,166.51 131.03,164.03 130.71,163.71 127.92,163.71 127.79,163.84 127.79,166.76 127.92,166.89 130.65,166.89
GND on BOTTOM (solid shape): 143.74,158.94 143.74,157.93 142.21,157.93 142.21,159.01 142.34,159.13 143.54,159.13
GND on BOTTOM (solid shape): 153.71,23.58 153.71,19.9 153.26,19.45 150.4,19.45 150.09,19.77 150.09,23.58 150.59,24.09 153.2,24.09
GND on BOTTOM (solid shape): 155.61,26.31 155.61,25.18 155.41,24.98 154.28,24.98 154.15,25.11 154.15,26.31 154.34,26.5 155.42,26.5
GND on BOTTOM (solid shape): 191.56,176.21 191.56,174.84 191.48,174.76 188.31,174.76 188.18,174.89 188.18,176.22 188.31,176.35 191.42,176.35
GND on BOTTOM (solid shape): 191.61,187.4 191.61,186.13 191.48,186 188.5,186 188.31,186.19 188.31,187.46 188.37,187.53 191.48,187.53
GND on BOTTOM (solid shape): 218.34,169.68 218.34,167.4 218.02,167.08 215.8,167.08 215.61,167.27 215.61,169.75 215.74,169.87 218.15,169.87
GND on BOTTOM (solid shape): 103.18,134.38 103.18,132.73 103.06,132.6 101.82,132.6 101.69,132.73 101.69,133.04 102.01,133.36 102.01,134.63 102.93,134.63
GND on BOTTOM (solid shape): 106.49,134.41 106.49,132.73 106.36,132.6 105.12,132.6 104.99,132.73 104.99,133.04 105.38,133.42 105.38,134.63 106.26,134.63
GND on BOTTOM (solid shape): 187.61,174 187.61,170.89 187.42,170.7 186.27,170.7 186.08,170.89 186.08,174 186.27,174.19 187.42,174.19
GND on BOTTOM (solid shape): 30.06,22.43 30.06,18.49 29.56,17.98 26.64,17.98 26.45,18.17 26.45,18.87 24.98,20.33 24.98,22.36 25.37,22.74 29.75,22.74
GND on BOTTOM (solid shape): 43.81,115.6 43.81,111.87 43.69,111.74 42.25,111.74 42.13,111.87 42.13,116.01 42.19,116.08 43.34,116.08
GND on BOTTOM (solid shape): 99.82,134.41 99.82,132.73 99.69,132.6 98.45,132.6 98.33,132.73 98.33,132.98 98.64,133.3 98.64,134.63 98.71,134.69 99.53,134.69
GND on BOTTOM (solid shape): 113.12,134.44 113.12,132.73 112.93,132.53 111.85,132.53 111.69,132.69 111.69,132.88 112.11,133.3 112.11,134.57 112.17,134.63 112.93,134.63
GND on BOTTOM (solid shape): 125.09,18.97 125.09,17.57 124.84,17.33 123.2,17.33 122.27,16.39 121.37,16.39 120.86,16.9 120.86,18.67 121.44,19.25 124.81,19.25
GND on BOTTOM (solid shape): 174.13,157.93 174.13,157.44 173.79,157.1 171.96,157.1 171.61,156.76 162.42,156.76 162.25,156.93 162.25,158.06 162.84,158.66 173.41,158.66
GND on BOTTOM (solid shape): 177.73,31.47 177.73,28.97 177.46,28.7 175.8,28.7 175.48,29.02 175.48,30.7 175.21,30.97 175.21,31.47 175.32,31.58 177.62,31.58
GND on BOTTOM (solid shape): 189.96,168.73 189.96,166.63 189.64,166.32 186.97,166.32 186.47,166.82 186.47,168.73 186.97,169.24 189.45,169.24
GND on BOTTOM (solid shape): 29.43,33.03 29.43,31.06 28.86,30.49 25.56,30.49 25.05,31 25.05,34.05 25.3,34.3 28.16,34.3
GND on BOTTOM (solid shape): 133.78,20.57 133.78,16.24 133.51,15.97 132.26,15.97 131.2,17.03 130.42,17.03 130.2,17.24 130.2,20.47 130.53,20.8 133.55,20.8
GND on BOTTOM (solid shape): 158.21,23.7 158.21,22.69 158.34,22.57 158.34,21.68 158.21,21.55 157.96,21.55 157.83,21.68 157.83,22.57 158.02,22.76 158.02,23.7 158.08,23.76 158.15,23.76
GND on BOTTOM (solid shape): 30.46,65.54 30.46,64.16 29.75,63.45 29.7,63.4 27.23,63.4 27.23,63.4 26.99,63.4 26.47,63.93 26.47,64.68 27.61,65.83 30.18,65.83
