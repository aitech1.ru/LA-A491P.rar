# Allegro board LAA491PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D63: length 62.7
  IN1 w0.084: v1(120.04,106.37) 120.41,106 120.41,104.27 123.9,100.78 123.9,98.22 126.67,95.45 127.71,95.45 128.53,94.63 128.93,94.63 129.33,94.23 129.33,93.94
  IN1 w0.127: v1(140.81,61.5) 140.75,61.56 140.75,61.86 140.87,61.99 141.1,61.99 141.23,62.11 141.23,62.42 141.1,62.55 140.46,62.55 140.33,62.67 140.33,62.95 140.46,63.08 141.1,63.08 141.23,63.21 141.23,63.56 141.17,63.61 140.46,63.61 140.33,63.74 140.33,64.02 140.46,64.15 141.1,64.15 141.23,64.27 141.23,65.33 141.08,65.48 140.56,65.48 140.43,65.61 140.43,66.04 140.55,66.15 141.22,66.15 141.32,66.26 141.32,66.52 141.19,66.65 140.6,66.65 140.39,66.86 140.39,70.06 140.55,70.22 140.72,70.22 140.85,70.35 140.85,70.61 140.72,70.74 140.47,70.74 140.34,70.86 140.34,77.65 132.13,85.86 132.13,90.5 129.33,93.31 129.33,93.94
  BOTTOM w0.076: UC1.AP18 120.36,106.69 v1(120.04,106.37)
  BOTTOM w0.102: v1(140.81,61.5) 140.45,61.86 JDIMM2.68
DDR_B_DQS0: length 81.9
  IN3 w0.084: 113.96,94.37 113.96,94.63 113.04,95.55 113.04,99.67 112.22,100.48 112.11,100.48 v1(111.96,100.32)
  IN3 w0.127: v1(163.03,68.61) 163.03,68.46 163.16,68.34 163.35,68.34 163.46,68.44 163.46,74.17 155.1,82.52 151.94,82.52 150.84,83.63 150.02,83.63 149.11,84.54 122.28,84.54 117.23,89.59 116.88,89.59 113.96,92.52 113.96,94.37
  BOTTOM w0.076: v1(111.96,100.32) 111.81,100.47 111.66,100.47 111.37,100.76 111.37,101.24 111.55,101.42 111.55,102.57 111.79,102.81 111.79,103 111.75,103.1 111.75,103.1 111.72,103.16 111.72,103.36 111.79,103.52 111.79,103.65 111.75,103.75 111.72,103.81 111.72,104.01 111.79,104.15 111.79,104.16 111.86,104.23 111.95,104.32 112.1,104.32 112.18,104.4 UC1.AV30
  BOTTOM w0.102: JDIMM2.137 163.55,70.44 163.26,70.15 163.03,70.15 162.55,69.67 162.55,68.5 162.82,68.23 162.89,68.23 163.03,68.37 v1(163.03,68.61)
DDR_B_DQS1: length 56.2
  IN1 w0.084: v1(115.67,99.02) 115.52,98.88 115.28,98.88 114.23,97.82 114.23,94.32 114.36,94.18 114.36,94.02 114.42,93.96
  IN1 w0.127: 114.42,93.96 114.44,93.94 114.44,78.87 121.86,71.45 121.86,66.99 122.46,66.39 122.46,64.21 122.33,64.08 121.97,64.08 121.7,63.81 121.7,63.22 121.97,62.94 122.29,62.94 122.51,62.72 122.51,60.09 122.9,59.7 123.3,59.7 v1(123.41,59.59)
  BOTTOM w0.076: UC1.AW26 114.43,103.91 114.39,103.87 114.39,103.48 114.37,103.43 114.33,103.34 114.32,103.32 114.32,103.19 114.34,103.14 114.39,103.03 114.39,102.63 114.1,102.34 114.02,102.26 114.02,101.93 114.64,101.32 114.64,99.18 114.95,98.86 115.51,98.86 v1(115.67,99.02)
  BOTTOM w0.102: JDIMM2.12 123.65,62.2 123.45,62 123.45,61.93 124.05,61.33 124.05,60.05 123.86,59.86 123.67,59.86 v1(123.41,59.59)
DDR_B_DQS2: length 89
  IN3 w0.084: 119.32,93.61 118.87,94.06 118.14,94.06 117.81,94.39 117.62,94.39 117.22,94.79 116.04,95.97 116.04,101.13 115.18,101.99 115.18,102.87 112.93,105.13 112.93,107.31 113.09,107.47 113.28,107.47 v1(113.48,107.67)
  IN3 w0.127: v1(169.07,66.32) 168.82,66.57 168.65,66.57 168.39,66.83 168.39,68.64 169.03,69.28 169.03,72.39 168.16,73.26 168.16,76 156.21,87.95 151.81,87.95 150.9,88.86 124.07,88.86 119.32,93.61
  BOTTOM w0.076: v1(113.48,107.67) 113.8,107.99 UC1.AM28
  BOTTOM w0.102: v1(169.07,66.32) 168.83,66.57 168.72,66.57 168.66,66.5 168.66,64.94 168.38,64.65 168.38,64.52 168.65,64.24 JDIMM2.154
DDR_B_DQS3: length 57.1
  IN1 w0.084: v1(115.37,107.73) 115.21,107.57 115,107.57 114.81,107.37 114.81,105.41 115.07,105.14 115.07,105.02 114.52,104.47 114.52,104.11 114.92,103.71 115.22,103.71 115.89,104.38 116.07,104.38 116.24,104.21 116.24,104.03 115.77,103.56 115.77,103.21 116.16,102.82 116.49,102.82 116.56,102.89 116.69,102.89 116.79,102.79 116.79,102.59 116.43,102.23 116.43,101.72 116.91,101.23 116.91,96.32 118.8,94.44 118.8,93.94
  IN1 w0.127: v1(127.98,67.58) 127.81,67.75 127.42,67.75 127.16,68.02 127.16,74.27 119.49,81.95 119.49,84.64 119.37,84.76 119.06,84.76 118.79,85.04 118.79,85.63 119.06,85.9 119.37,85.9 119.49,86.03 119.49,86.41 119.37,86.54 119.06,86.54 118.79,86.81 118.79,87.4 119.06,87.68 119.37,87.68 119.49,87.8 119.49,88.18 119.37,88.31 119.06,88.31 118.79,88.58 118.79,89.17 119.06,89.45 119.4,89.45 119.47,89.52 119.47,89.93 119.32,90.08 119.07,90.08 118.8,90.36 118.8,93.94
  BOTTOM w0.076: UC1.AM25 115.63,107.99 v1(115.37,107.73)
  BOTTOM w0.102: JDIMM2.29 128.75,70.42 128.59,70.25 128.59,68.05 128.39,67.86 128.26,67.86 v1(127.98,67.58)
DDR_B_DQS4: length 86.7
  IN3 w0.084: 127.77,93.94 127.64,94.07 127.64,94.1 127.61,94.14 126.72,95.02 120.98,95.02 120.13,95.87 118.94,95.87 118.59,96.23 118.59,100.21 117.99,100.81 117.68,100.81 117.57,100.7 v1(117.57,100.58)
  IN3 w0.127: v1(173.9,68.61) 173.9,68.43 174.03,68.3 174.22,68.3 174.32,68.39 174.32,69.59 173.93,69.97 173.93,76.95 158.59,92.3 157.61,92.3 156.62,93.29 139.73,93.29 139.39,93.63 128.08,93.63 127.77,93.94
  BOTTOM w0.076: UC1.AV22 117.31,104.4 117.23,104.32 117.08,104.32 116.99,104.23 116.92,104.16 116.92,104.15 116.85,104.01 116.85,103.81 116.88,103.75 116.93,103.65 116.93,103.52 116.85,103.36 116.85,103.16 116.88,103.1 116.88,103.1 116.93,103 116.93,102.81 116.81,102.7 116.81,102.08 117.05,101.84 117.05,101.1 v1(117.57,100.58)
  BOTTOM w0.102: JDIMM2.171 173.75,70.42 173.52,70.19 173.52,69.86 173.45,69.79 173.45,68.42 173.53,68.34 173.77,68.34 173.9,68.47 v1(173.9,68.61)
DDR_B_DQS5: length 54.4
  IN1 w0.084: v1(121.05,98.3) 121.05,98.13 120.91,97.99 120.53,97.99 120.31,97.77 120.31,96.14 120.95,95.5 122.01,95.5 122.8,94.7 122.8,93.92 123.11,93.62 123.11,93.61
  IN1 w0.127: v1(133.6,68.42) 133.6,68.25 133.72,68.12 133.9,68.12 134.01,68.24 134.01,69.69 133.89,69.81 133.76,69.81 133.48,70.09 133.48,70.68 133.76,70.95 133.89,70.95 134.01,71.08 134.01,71.46 133.89,71.59 133.76,71.59 133.48,71.86 133.48,72.45 133.76,72.72 133.89,72.72 134.01,72.85 134.01,73.23 133.89,73.36 133.78,73.36 133.51,73.63 133.51,75.46 125.04,83.93 125.04,84.64 124.89,84.79 124.19,84.79 123.92,85.06 123.92,85.65 124.19,85.93 124.91,85.93 125.04,86.06 125.04,86.44 124.91,86.56 124.04,86.56 123.78,86.82 123.78,87.43 124.06,87.7 124.36,87.7 124.49,87.83 124.49,88.21 124.36,88.34 124.06,88.34 123.78,88.61 123.78,91.63 123.11,92.31 123.11,93.61
  BOTTOM w0.076: UC1.AW18 119.69,103.96 119.6,103.96 119.52,103.88 119.52,103.48 119.5,103.43 119.46,103.34 119.45,103.32 119.45,103.19 119.48,103.14 119.5,103.08 119.5,103.08 119.52,103.03 119.52,102.72 119.28,102.48 119.28,102.16 120.18,101.26 120.18,98.33 120.62,97.89 120.78,97.89 121.05,98.17 v1(121.05,98.3)
  BOTTOM w0.102: v1(133.6,68.42) 133.63,68.38 133.63,68.17 133.52,68.06 133.15,68.06 133,68.21 133,69.16 133.83,69.99 133.83,70.18 134.15,70.5 JDIMM2.47
DDR_B_DQS6: length 94.7
  IN3 w0.084: 131.57,98.69 131.51,98.69 131.47,98.73 129.86,98.73 129.16,98.03 123.54,98.03 122.72,98.85 122.72,101.22 119.29,104.65 118.43,104.65 117.58,105.5 117.58,107.25 117.82,107.48 117.95,107.48 v1(118.13,107.67)
  IN3 w0.127: v1(179.93,66.32) 179.78,66.48 179.54,66.48 179.25,66.77 179.25,78.25 159.89,97.61 144.96,97.61 144.08,98.49 137.54,98.49 137.34,98.69 131.57,98.69
  BOTTOM w0.076: UC1.AM21 118.52,107.77 118.42,107.67 v1(118.13,107.67)
  BOTTOM w0.102: v1(179.93,66.32) 179.93,66.55 179.82,66.66 179.6,66.66 179.42,66.48 179.42,64.85 178.85,64.28 JDIMM2.188
DDR_B_DQS7: length 63.4
  IN1 w0.084: 128.09,93.94 128.09,93.95 128.11,93.97 128.11,94.12 127.34,94.88 126.39,94.88 122.65,98.63 122.65,101.04 121.57,102.11 121.57,102.37 119.48,104.47 119.48,107.27 119.69,107.49 119.85,107.49 v1(120.04,107.67)
  IN1 w0.127: 128.09,93.94 128.09,92.79 130.91,89.97 130.91,85.35 139.1,77.16 139.1,62.38 138.83,62.11 138.33,62.11 137.95,61.73 137.95,60.14 138.33,59.76 138.53,59.76 v1(138.7,59.59)
  BOTTOM w0.076: UC1.AM18 120.1,107.67 v1(120.04,107.67)
  BOTTOM w0.102: JDIMM2.64 139.25,62.19 139.18,62.12 139.18,61.5 139.61,61.07 139.61,59.9 139.35,59.64 138.74,59.64 v1(138.7,59.59)
DDR_B_DQS#0: length 82.1
  IN3 w0.084: 114.2,94.37 114.2,94.63 113.21,95.62 113.21,99.74 112.3,100.65 112.18,100.65 111.96,100.87 v1(111.96,100.97)
  IN3 w0.127: 114.2,94.37 114.2,92.62 116.99,89.83 117.33,89.83 122.38,84.78 149.21,84.78 150.12,83.87 150.94,83.87 152.04,82.77 155.2,82.77 163.7,74.27 163.7,68.34 163.45,68.09 163.28,68.09 v1(163.03,67.85)
  BOTTOM w0.076: UC1.AW30 112.18,104.09 112.11,104.16 112.02,104.16 111.94,104.08 111.89,103.97 111.89,103.84 111.96,103.69 111.96,103.48 111.94,103.43 111.89,103.34 111.89,103.32 111.89,103.19 111.91,103.14 111.94,103.08 111.94,103.08 111.96,103.03 111.96,102.74 111.72,102.5 111.72,101.36 111.54,101.17 111.54,100.83 111.71,100.66 111.8,100.66 111.96,100.81 v1(111.96,100.97)
  BOTTOM w0.102: JDIMM2.135 162.95,70.36 162.35,69.76 162.35,68.42 162.74,68.03 162.85,68.03 v1(163.03,67.85)
DDR_B_DQS#1: length 56.5
  IN1 w0.084: 114.59,94.14 114.57,94.16 114.57,94.27 114.43,94.41 114.43,97.74 115.36,98.67 115.56,98.67 115.67,98.56 v1(115.67,98.37)
  IN1 w0.127: v1(123.41,60.36) 123.41,60.17 123.19,59.95 123.01,59.95 122.76,60.2 122.76,62.82 122.39,63.19 122.08,63.19 121.95,63.32 121.95,63.7 122.08,63.83 122.43,63.83 122.71,64.1 122.71,66.5 122.11,67.09 122.11,71.55 114.69,78.97 114.69,94.04 114.59,94.14
  BOTTOM w0.076: v1(115.67,98.37) 115.67,98.49 115.46,98.7 114.89,98.7 114.47,99.11 114.47,101.25 113.86,101.87 113.86,102.33 113.98,102.46 114.23,102.7 114.23,103 114.15,103.16 114.15,103.36 114.23,103.52 114.23,104 114.38,104.16 114.38,104.33 UC1.AV26
  BOTTOM w0.102: JDIMM2.10 123.05,62.19 123.26,61.99 123.26,61.85 123.85,61.25 123.85,60.14 123.78,60.06 123.71,60.06 v1(123.41,60.36)
DDR_B_DQS#2: length 89.1
  IN3 w0.084: 119.47,93.8 119.41,93.8 118.98,94.23 118.21,94.23 117.88,94.56 117.69,94.56 116.22,96.04 116.22,101.2 115.36,102.06 115.36,102.94 113.1,105.2 113.1,107.24 113.16,107.3 113.36,107.3 113.48,107.18 v1(113.48,107.02)
  IN3 w0.127: v1(169.07,67.09) 169.07,66.91 168.97,66.81 168.75,66.81 168.63,66.93 168.63,68.54 169.27,69.18 169.27,72.49 168.4,73.36 168.4,76.1 156.31,88.19 151.91,88.19 151,89.1 124.17,89.1 119.47,93.8
  BOTTOM w0.076: v1(113.48,107.02) 113.81,107.02 113.87,107.08 UC1.AN28
  BOTTOM w0.102: JDIMM2.152 168.05,64.34 168.18,64.46 168.18,64.74 168.46,65.02 168.46,66.59 168.64,66.76 168.9,66.76 169.07,66.93 v1(169.07,67.09)
DDR_B_DQS#3: length 57.2
  IN1 w0.084: 119.05,93.61 119.05,93.95 119.03,93.97 119.03,94.03 119,94.06 119,94.52 117.12,96.4 117.12,101.32 116.64,101.8 116.64,102.14 117,102.5 117,102.88 116.78,103.1 116.47,103.1 116.4,103.03 116.25,103.03 115.98,103.29 115.98,103.47 116.45,103.94 116.45,104.29 116.16,104.58 115.81,104.58 115.14,103.91 115.01,103.91 114.73,104.2 114.73,104.38 115.28,104.93 115.28,105.23 114.99,105.52 114.99,107.26 115.09,107.36 115.56,107.36 115.61,107.31 115.61,107.11 115.46,106.95 v1(115.37,106.95)
  IN1 w0.127: 119.05,93.61 119.05,90.46 119.17,90.33 119.42,90.33 119.72,90.03 119.72,89.42 119.5,89.2 119.17,89.2 119.04,89.07 119.04,88.69 119.17,88.56 119.47,88.56 119.75,88.29 119.75,87.7 119.47,87.42 119.17,87.42 119.04,87.3 119.04,86.92 119.17,86.79 119.47,86.79 119.75,86.51 119.75,85.92 119.47,85.65 119.17,85.65 119.04,85.52 119.04,85.14 119.17,85.02 119.47,85.02 119.74,84.75 119.74,82.05 127.41,74.38 127.41,68.12 127.52,68.01 127.89,68.01 127.98,68.09 v1(127.98,68.34)
  BOTTOM w0.076: v1(115.37,106.95) 115.61,106.95 115.77,107.12 UC1.AN25
  BOTTOM w0.102: JDIMM2.27 128.15,70.49 128.39,70.25 128.39,68.14 128.31,68.06 128.26,68.06 v1(127.98,68.34)
DDR_B_DQS#4: length 86.8
  IN3 w0.084: v1(117.57,101.16) 117.76,100.98 118.06,100.98 118.76,100.28 118.76,96.3 119.02,96.05 120.2,96.05 121.06,95.19 126.8,95.19 127.88,94.11 127.94,94.11
  IN3 w0.127: 127.94,94.11 128.18,93.87 139.49,93.87 139.83,93.53 156.72,93.53 157.71,92.54 158.69,92.54 174.18,77.05 174.18,70.07 174.56,69.69 174.56,68.29 174.32,68.06 174.04,68.06 173.9,67.91 v1(173.9,67.85)
  BOTTOM w0.076: v1(117.57,101.16) 117.28,101.16 117.22,101.23 117.22,101.91 116.98,102.15 116.98,102.63 117.09,102.74 117.09,103.03 117.07,103.09 117.02,103.19 117.02,103.32 117.03,103.34 117.07,103.43 117.09,103.48 117.09,103.69 117.02,103.84 117.02,103.97 117.07,104.08 117.15,104.16 117.24,104.16 117.31,104.09 UC1.AW22
  BOTTOM w0.102: JDIMM2.169 173.15,70.41 173.32,70.24 173.32,69.94 173.25,69.87 173.25,68.33 173.44,68.14 173.77,68.14 173.9,68.01 v1(173.9,67.85)
DDR_B_DQS#5: length 54.8
  IN1 w0.084: 123.36,93.61 123.36,93.62 123.34,93.65 123.34,93.71 123.2,93.84 123.18,93.84 123.01,94.01 123.01,94.79 122.09,95.7 121.03,95.7 120.51,96.23 120.51,97.68 120.61,97.78 120.92,97.78 v1(121.05,97.65)
  IN1 w0.127: v1(133.6,67.66) 133.6,67.66 133.81,67.87 134,67.87 134.27,68.13 134.27,69.79 133.99,70.06 133.86,70.06 133.73,70.19 133.73,70.57 133.86,70.7 133.99,70.7 134.27,70.97 134.27,71.56 133.99,71.84 133.86,71.84 133.73,71.96 133.73,72.35 133.86,72.47 133.99,72.47 134.27,72.75 134.27,73.34 133.99,73.61 133.88,73.61 133.76,73.74 133.76,75.57 125.29,84.04 125.29,84.75 124.99,85.04 124.3,85.04 124.17,85.17 124.17,85.55 124.3,85.68 125.01,85.68 125.29,85.95 125.29,86.54 125.01,86.81 124.15,86.81 124.04,86.93 124.04,87.32 124.16,87.45 124.47,87.45 124.74,87.72 124.74,88.31 124.47,88.59 124.16,88.59 124.04,88.71 124.04,91.74 123.36,92.41 123.36,93.61
  BOTTOM w0.076: UC1.AV18 119.52,104.33 119.52,104.16 119.36,104 119.36,103.52 119.29,103.36 119.29,103.16 119.36,103 119.36,102.8 119.12,102.56 119.12,102.09 120.02,101.19 120.02,98.26 120.55,97.73 120.97,97.73 v1(121.05,97.65)
  BOTTOM w0.102: v1(133.6,67.66) 133.39,67.86 133.07,67.86 132.8,68.13 132.8,69.24 133.63,70.08 133.63,70.43 133.55,70.51 JDIMM2.45
DDR_B_DQS#6: length 94.9
  IN3 w0.084: 131.55,98.93 131.53,98.9 129.79,98.9 129.09,98.2 123.61,98.2 122.89,98.92 122.89,101.29 119.36,104.83 118.5,104.83 117.76,105.57 117.76,107.18 117.89,107.31 118.02,107.31 118.13,107.2 v1(118.13,107.02)
  IN3 w0.127: 131.55,98.93 137.44,98.93 137.64,98.73 144.18,98.73 145.06,97.85 159.99,97.85 179.49,78.35 179.49,66.87 179.64,66.72 179.77,66.72 179.93,66.88 v1(179.93,67.09)
  BOTTOM w0.076: UC1.AN21 118.46,107.34 v1(118.13,107.02)
  BOTTOM w0.102: JDIMM2.186 178.25,64.31 178.43,64.5 178.79,64.5 179.22,64.93 179.22,66.57 179.51,66.86 179.7,66.86 v1(179.93,67.09)
DDR_B_DQS#7: length 63.6
  IN1 w0.084: 128.34,93.94 128.34,94.18 127.42,95.09 126.48,95.09 122.86,98.71 122.86,101.12 121.78,102.2 121.78,102.41 119.67,104.52 119.67,107.22 119.73,107.28 119.97,107.28 120.04,107.2 v1(120.04,107.02)
  IN1 w0.127: v1(138.7,60.36) 138.7,60.11 138.6,60.02 138.44,60.02 138.2,60.25 138.2,61.63 138.44,61.86 138.93,61.86 139.35,62.28 139.35,77.26 131.16,85.46 131.16,90.08 128.34,92.9 128.34,93.94
  BOTTOM w0.089: UC1.AN18 120.47,107.34 120.55,107.26 120.55,107.08 120.49,107.02 v1(120.04,107.02)
  BOTTOM w0.102: JDIMM2.62 138.65,62.1 138.73,62.02 138.88,62.02 138.98,61.92 138.98,61.41 139.41,60.98 139.41,59.98 139.27,59.83 139.03,59.83 138.7,60.17 v1(138.7,60.36)
DDR_B_MA0: length 80.9
  IN3 w0.084: 104.78,93.66 104.78,93.8 105.19,94.2 105.19,98.34 105.88,99.04 105.88,105.15 106.1,105.37 106.1,106.02 v1(105.76,106.37)
  IN3 w0.208: 104.78,93.66 104.78,88.67 120.1,73.34 148.5,73.34 150.96,70.89 150.96,70.34 151.62,69.68 151.62,66.14 v1(151.16,65.67)
  BOTTOM w0.076: UC1.AP40 106.08,106.69 v1(105.76,106.37)
  BOTTOM w0.165: v1(151.16,65.67) 151.85,64.98 JDIMM2.98
DDR_B_MA1: length 81.2
  IN3 w0.084: 104.31,93.66 104.31,94.01 104.01,94.31 104.01,95.47 104.89,96.35 104.89,99.82 105.53,100.46 105.53,105.52 v1(105.73,105.72)
  IN3 w0.208: 104.31,93.66 104.31,88.49 120.5,72.3 125.38,72.3 125.96,72.87 128.26,72.87 128.84,72.3 132.14,72.3 132.72,72.87 134.92,72.87 135.5,72.3 136.36,72.3 136.58,72.51 136.58,72.66 136.79,72.87 137.23,72.87 137.44,72.66 137.44,72.5 137.65,72.3 138.85,72.3 139.05,72.5 139.05,72.66 139.26,72.87 139.7,72.87 139.91,72.66 139.91,72.51 140.13,72.3 140.88,72.3 141.46,72.87 144.63,72.87 145.12,72.38 145.43,72.38 145.89,72.84 146.38,72.84 146.84,72.38 147.22,72.38 147.72,72.87 148.31,72.87 150.49,70.69 150.49,68.92 150.7,68.72 v1(151.16,68.72)
  BOTTOM w0.076: UC1.AR40 106.06,106.04 v1(105.73,105.72)
  BOTTOM w0.165: v1(151.16,68.72) 151.6,69.16 151.6,70.17 151.55,70.22 JDIMM2.97
DDR_B_MA2: length 85.9
  IN3 w0.084: v1(104.84,106.42) 104.29,105.86 104.29,96.6 103.66,95.97 103.66,94.24 103.37,93.95 103.37,93.66
  IN3 w0.208: v1(150.62,60.74) 149.55,61.8 149.55,69.67 147.86,71.36 119.46,71.36 118.08,72.73 118.08,73.39 103.37,88.1 103.37,93.66
  BOTTOM w0.076: v1(104.84,106.42) 105.12,106.69 UC1.AP42
  BOTTOM w0.165: JDIMM2.96 151.25,61.37 v1(150.62,60.74)
DDR_B_MA3: length 82.7
  IN3 w0.084: v1(104.84,105.77) 104.65,105.58 104.65,96.61 103.84,95.81 103.84,93.66
  IN3 w0.208: 103.84,93.66 103.84,88.29 118.55,73.58 118.55,72.93 119.65,71.83 125.58,71.83 126.15,72.41 128.07,72.41 128.64,71.83 132.34,71.83 132.92,72.41 134.72,72.41 135.3,71.83 141.07,71.83 141.65,72.41 143.84,72.41 144.33,71.91 148.61,71.91 150.02,70.5 150.02,67.4 150.23,67.2 v1(151.16,67.2)
  BOTTOM w0.076: UC1.AR42 105.12,106.04 v1(104.84,105.77)
  BOTTOM w0.165: v1(151.16,67.2) 150.72,67.64 150.72,70.02 150.95,70.25 JDIMM2.95
DDR_B_MA4: length 90.1
  IN3 w0.084: 101.96,93.66 101.96,95.85 102.28,96.17 102.28,101.58 101.68,102.17 101.68,102.49 101.95,102.75 102.09,102.75 102.51,103.18 102.51,105.37 v1(102.94,105.79)
  IN3 w0.208: v1(149.08,60.74) 148.43,61.39 148.43,65.36 147.68,66.11 147.68,68.96 146.69,69.95 140.62,69.95 140.16,69.49 140.16,68.19 138.68,66.71 135.14,66.71 134.86,66.43 132.89,66.43 132.61,66.71 129.16,66.71 128.81,67.07 128.81,68.93 128.17,69.57 125.88,69.57 125.5,69.95 118.87,69.95 116.67,72.15 116.67,72.8 101.96,87.51 101.96,93.66
  BOTTOM w0.076: UC1.AR45 103.19,106.04 v1(102.94,105.79)
  BOTTOM w0.165: JDIMM2.92 150.05,61.71 v1(149.08,60.74)
DDR_B_MA5: length 86.8
  IN3 w0.084: v1(102.94,106.44) 103.4,106.44 103.47,106.37 103.47,105.36 103.95,104.88 103.95,99.2 103.87,99.12 103.19,99.12 103.13,99.05 103.13,95.62 102.71,95.2 102.71,94.18 102.9,93.99 102.9,93.66
  IN3 w0.208: 102.9,93.66 102.9,87.9 117.61,73.19 117.61,72.54 119.26,70.89 126.27,70.89 126.65,70.51 127.14,70.51 127.52,70.89 128,70.89 128.38,70.51 128.86,70.51 129.24,70.89 130.17,70.89 130.3,70.76 130.3,68.8 130.43,68.67 131.02,68.67 131.15,68.8 131.15,70.76 131.27,70.89 132.15,70.89 132.53,70.51 133.01,70.51 133.39,70.89 133.88,70.89 134.26,70.51 134.74,70.51 135.12,70.89 135.59,70.89 135.96,70.51 136.65,70.51 137.02,70.89 147.67,70.89 148.62,69.94 148.62,68.78 148.75,68.65 149.01,68.65 v1(149.08,68.72)
  BOTTOM w0.076: UC1.AP45 103.19,106.69 v1(102.94,106.44)
  BOTTOM w0.165: JDIMM2.91 149.75,69.67 150.29,69.13 150.29,68.29 150.09,68.08 149.77,68.08 149.57,68.29 149.57,68.52 149.37,68.72 v1(149.08,68.72)
DDR_B_MA6: length 93
  IN3 w0.084: v1(101.97,103.28) 101.51,102.82 101.51,102.1 102.06,101.55 102.06,96.53 101.49,95.96 101.49,93.66
  IN3 w0.208: v1(149.08,59.21) 147.96,60.34 147.96,62.52 147.21,63.27 147.21,68.76 146.49,69.48 141.63,69.48 141.32,69.16 141.32,67.05 141,66.73 139.71,66.73 139.22,66.24 135.33,66.24 135.06,65.96 132.69,65.96 132.41,66.24 124.74,66.24 124.53,66.46 124.53,67.07 124.4,67.19 123.58,67.19 123.45,67.07 123.45,66.46 123.23,66.24 121.04,66.24 120.27,67.01 120.27,69.27 120.07,69.48 118.68,69.48 116.2,71.96 116.2,72.61 101.49,87.32 101.49,93.66
  BOTTOM w0.076: v1(101.97,103.28) 101.98,103.28 102.28,103.58 UC1.AW46
  BOTTOM w0.165: JDIMM2.90 149.45,62.12 149.32,61.99 148.95,61.99 148.62,61.66 148.62,59.68 v1(149.08,59.21)
DDR_B_MA7: length 91.2
  IN3 w0.084: 98.01,93.66 98.01,95.33 100.17,97.48 v1(100.17,100.11)
  IN3 w0.208: 98.01,93.66 98.01,86.09 107.15,76.95 107.15,74.13 118.84,62.43 141.58,62.43 141.78,62.23 141.78,60.72 141.91,60.59 142.52,60.59 142.64,60.72 142.64,62.23 142.85,62.43 143.3,62.43 143.51,62.23 143.51,60.72 143.63,60.59 144.24,60.59 144.37,60.72 144.37,62.23 144.57,62.43 146.76,62.43 146.97,62.23 146.97,60.94 147.17,60.74 v1(147.43,60.74)
  BOTTOM w0.076: UC1.AY46 102.45,102.86 102.45,101.23 101.5,100.28 100.33,100.28 v1(100.17,100.11)
  BOTTOM w0.165: v1(147.43,60.74) 147.87,61.18 147.87,61.73 148.25,62.11 JDIMM2.86
DDR_B_MA8: length 89.9
  IN3 w0.084: 102.43,93.66 102.19,93.9 102.19,95.43 102.47,95.71 102.47,101.91 v1(102.05,102.33)
  IN3 w0.208: v1(149.08,67.2) 148.42,67.2 148.15,67.47 148.15,69.15 146.88,70.42 139.74,70.42 139.62,70.29 139.62,69.16 139.49,69.03 138.89,69.03 138.76,69.16 138.76,70.24 138.63,70.37 137.15,70.37 137.03,70.24 137.03,68.4 136.9,68.27 136.32,68.27 136.19,68.4 136.19,69.92 136.07,70.05 135.18,70.05 135.05,69.92 135.05,68.4 134.93,68.27 134.19,68.27 134.06,68.4 134.06,69.91 133.93,70.04 131.81,70.04 131.61,69.83 131.61,68.34 131.48,68.21 129.97,68.21 129.84,68.34 129.84,69.91 129.71,70.04 126.08,70.04 125.7,70.42 119.07,70.42 117.14,72.34 117.14,73 102.43,87.71 102.43,93.66
  BOTTOM w0.076: UC1.AY47 101.55,102.75 101.97,102.33 v1(102.05,102.33)
  BOTTOM w0.165: v1(149.08,67.2) 148.37,67.9 148.37,69.49 149.15,70.26 JDIMM2.89
DDR_B_MA9: length 92.4
  IN3 w0.084: 101.02,93.66 101.02,95.83 101.23,96.04 101.23,99.51 101.74,100.01 101.74,101.63 101.34,102.03 101.34,103.94 v1(101.98,104.58)
  IN3 w0.208: v1(146.58,68.72) 146.27,68.72 146.15,68.59 146.15,68.11 146.02,67.98 145.41,67.98 145.28,68.11 145.28,68.88 145.16,69.01 143.64,69.01 143.51,68.88 143.51,68.05 143.39,67.92 142.78,67.92 142.65,68.05 142.65,68.88 142.52,69.01 141.91,69.01 141.79,68.88 141.79,66.85 141.2,66.26 140.01,66.26 139.51,65.77 135.53,65.77 135.25,65.49 132.5,65.49 132.22,65.77 120.84,65.77 119.8,66.81 119.8,68.8 119.6,69.01 118.18,69.01 117.39,68.22 117.1,68.22 116.78,68.54 116.78,68.83 117.57,69.62 117.57,69.92 117.26,70.23 116.96,70.23 116.17,69.44 115.88,69.44 115.56,69.76 115.56,70.05 116.35,70.84 116.35,71.15 116.04,71.45 115.73,71.45 114.95,70.66 114.66,70.66 114.33,70.98 114.33,71.27 115.41,72.35 115.41,72.73 101.02,87.12 101.02,93.66
  BOTTOM w0.076: v1(101.98,104.58) 102.13,104.58 UC1.AU46
  BOTTOM w0.165: v1(146.58,68.72) 147.1,68.72 147.95,69.57 JDIMM2.85
DDR_B_MA10: length 96.7
  IN3 w0.084: v1(108.18,109.12) 108.49,109.12 108.59,109.02 108.59,104.96 108.85,104.69 108.85,99.88 107.53,98.56 107.53,97.1 107.75,96.89 107.75,96.47
  IN3 w0.208: 107.75,96.47 107.75,89.91 119.33,78.33 124.43,78.33 124.64,78.12 124.64,76.51 124.84,76.31 125.3,76.31 125.5,76.51 125.5,78.12 125.7,78.33 126.16,78.33 126.36,78.12 126.36,76.51 126.57,76.31 127.02,76.31 127.23,76.51 127.23,78.12 127.43,78.33 127.89,78.33 128.09,78.12 128.09,76.51 128.29,76.31 150.51,76.31 152.04,74.78 152.32,74.78 152.99,75.45 153.32,75.45 153.66,75.11 153.66,74.78 153.45,74.56 153.45,74.37 154.08,73.74 154.08,73.48 153.95,73.35 153.95,73.02 154.25,72.72 154.57,72.72 154.82,72.97 155.11,72.97 155.4,72.69 155.4,72.32 155.17,72.1 155.17,71.8 155.4,71.57 155.4,67.32 155.52,67.2 v1(155.87,67.2)
  BOTTOM w0.076: v1(108.18,109.12) 108.36,109.29 UC1.AK36
  BOTTOM w0.165: JDIMM2.107 154.55,68.51 v1(155.87,67.2)
DDR_B_MA11: length 93.1
  IN3 w0.084: v1(100.17,100.67) 99.79,100.29 99.79,97.47 97.54,95.22 97.54,93.66
  IN3 w0.208: v1(147.43,59.21) 146.7,59.21 146.5,59.42 146.5,61.76 146.29,61.96 145.04,61.96 144.84,61.76 144.84,60.16 144.64,59.95 141.51,59.95 141.31,60.16 141.31,61.76 141.11,61.96 118.65,61.96 106.68,73.93 106.68,76.76 97.54,85.89 97.54,93.66
  BOTTOM w0.076: v1(100.17,100.67) 100.22,100.62 101.4,100.62 101.58,100.8 101.58,102.43 101.26,102.74 101.26,103.94 UC1.AV47
  BOTTOM w0.165: v1(147.43,59.21) 146.97,59.68 146.97,61.73 147.65,62.41 JDIMM2.84
DDR_B_MA12: length 88.6
  IN3 w0.084: v1(100.39,103.23) 100.77,102.85 100.77,102.08 100.54,101.86 100.54,97.21 98.48,95.15 98.48,93.66
  IN3 w0.208: v1(146.58,67.2) 146.02,66.63 146.02,63.19 145.73,62.9 119.04,62.9 107.62,74.32 107.62,77.15 98.48,86.28 98.48,93.66
  BOTTOM w0.076: UC1.AU47 101.51,104.6 101.1,104.19 101.1,103.46 100.89,103.25 100.42,103.25 v1(100.39,103.23)
  BOTTOM w0.165: v1(146.58,67.2) 146.14,67.64 146.14,69.42 147.35,70.62 JDIMM2.83
DDR_B_MA13: length 96.5
  IN3 w0.084: v1(110.09,109.03) 110.39,109.03 110.48,108.94 110.48,107.4 110.66,107.22 110.66,103.07 111.09,102.64 111.09,101.67 110.84,101.42 110.84,97.23 110.71,97.1 110.27,97.1 110.14,96.97 110.14,96.74 110.27,96.61 110.71,96.61 110.84,96.48 110.84,96.28 110.71,96.15 110.22,96.15 110.11,96.04
  IN3 w0.208: 110.11,96.04 110.1,96.02 110.1,90.88 120.3,80.68 142.33,80.68 142.53,80.47 142.53,78.86 142.73,78.66 143.19,78.66 143.39,78.86 143.39,80.47 143.6,80.68 144.05,80.68 144.26,80.47 144.26,78.86 144.46,78.66 144.92,78.66 145.12,78.86 145.12,80.47 145.32,80.68 145.78,80.68 145.98,80.47 145.98,78.86 146.19,78.66 146.65,78.66 146.85,78.86 146.85,80.47 147.05,80.68 147.51,80.68 147.71,80.47 147.71,78.86 147.92,78.66 153.49,78.66 159.09,73.06 159.09,68.85 v1(158.96,68.72)
  BOTTOM w0.076: UC1.AK33 110.35,109.29 v1(110.09,109.03)
  BOTTOM w0.165: v1(158.96,68.72) 158.15,69.53 JDIMM2.119
DDR_B_MA14: length 93.1
  IN3 w0.084: 97.07,93.66 97.07,95 99.58,97.5 99.58,100.8 100.15,101.36 100.15,102.1 99.85,102.4 99.85,104.52 100.46,105.13 101.42,105.13 101.98,105.7 v1(101.98,105.85)
  IN3 w0.208: 97.07,93.66 97.07,85.7 106.21,76.56 106.21,73.74 121.96,57.99 138.96,57.99 139.16,58.19 139.16,60.01 139.37,60.21 140.04,60.21 140.24,60.01 140.24,58.68 140.37,58.56 144.64,58.56 144.77,58.68 144.77,59.42 145.31,59.96 145.31,60.27 v1(145.78,60.74)
  BOTTOM w0.076: v1(101.98,105.85) 102.28,105.85 UC1.AR46
  BOTTOM w0.165: JDIMM2.80 146.45,61.41 v1(145.78,60.74)
DDR_B_MA15: length 93.7
  IN3 w0.084: v1(101.98,106.5) 101.86,106.63 101.63,106.63 101.5,106.5 101.5,105.53 101.3,105.32 100.4,105.32 99.67,104.6 99.67,102.33 99.97,102.03 99.97,101.43 99.41,100.87 99.41,97.67 96.6,94.86 96.6,93.66
  IN3 w0.208: v1(145.78,59.21) 145.78,59.23 145.65,59.36 145.36,59.36 145.23,59.23 145.23,57.54 145.11,57.41 121.87,57.41 105.74,73.54 105.74,76.37 96.6,85.51 96.6,93.66
  BOTTOM w0.076: v1(101.98,106.5) 102.28,106.5 UC1.AP46
  BOTTOM w0.165: v1(145.78,59.21) 145.32,59.68 145.32,61.67 145.85,62.2 JDIMM2.78
DDR_B_RAS#: length 97.3
  IN3 w0.084: 108.69,96.34 108.69,96.8 108.87,96.98 108.87,99.13 109.29,99.55 109.29,105.2 109.54,105.45 109.54,107.26 v1(109.16,107.64)
  IN3 w0.208: 108.69,96.34 108.69,90.3 119.72,79.27 134.01,79.27 134.21,79.06 134.21,77.45 134.42,77.25 152.85,77.25 155.09,75.01 155.09,74.7 154.91,74.52 154.91,74.24 155.23,73.91 155.52,73.91 155.7,74.09 156.01,74.09 156.56,73.54 156.56,73.16 156.34,72.94 156.34,65.48 156.46,65.35 156.81,65.35 156.94,65.22 156.94,64.53 156.81,64.4 155.86,64.4 155.73,64.27 155.73,63.71 155.86,63.58 158.36,63.58 158.56,63.38 158.56,62.83 158.36,62.63 157.36,62.63 157.15,62.42 157.15,61.95 156.84,61.63 156.84,60.59 156.63,60.39 156.24,60.39 156.04,60.59 v1(156.04,60.74)
  BOTTOM w0.089: UC1.AM35 109.51,107.99 v1(109.16,107.64)
  BOTTOM w0.165: JDIMM2.110 155.45,61.32 v1(156.04,60.74)
DDR_B_WE#: length 95.8
  IN3 w0.084: v1(109.13,108.97) 109.5,108.97 109.64,108.83 109.64,107.44 109.73,107.35 109.73,105.35 109.48,105.1 109.48,103.12 110.01,102.59 110.01,102.37 109.48,101.85 109.48,99.45 109.16,99.12 109.16,96.18
  IN3 w0.208: 109.16,96.18 109.16,90.49 119.91,79.74 134.48,79.74 134.68,79.53 134.68,77.92 134.89,77.72 135.34,77.72 135.55,77.92 135.55,79.53 135.75,79.74 136.21,79.74 136.41,79.53 136.41,77.92 136.61,77.72 153.04,77.72 157.68,73.08 157.68,72.78 157.32,72.42 157.32,72.11 157.52,71.9 157.94,71.9 158.15,71.7 158.15,71.24 157.94,71.04 157.01,71.04 156.81,70.84 156.81,70.38 157.01,70.18 157.94,70.18 158.15,69.97 158.15,69.52 157.94,69.31 157.01,69.31 156.81,69.11 156.81,67.2 157,67.01 157.24,67.01 v1(157.43,67.2)
  BOTTOM w0.076: UC1.AK35 109.46,109.29 v1(109.13,108.97)
  BOTTOM w0.165: v1(157.43,67.2) 156.35,68.28 JDIMM2.113
DDR_CKE0_DIMMA: length 74.6
  IN1 w0.084: 97.69,93.66 97.69,94.04 99.95,96.3 100.9,96.3 103.98,99.38 103.98,104.16 v1(103.56,104.58)
  IN1 w0.183: v1(65.15,68.68) 64.56,69.27 64.56,71.21 65.15,71.8 65.15,73.67 65.87,74.39 66.18,74.39 67.16,75.37 67.16,75.63 66.62,76.16 66.62,76.35 66.95,76.68 67.21,76.68 67.75,76.14 67.93,76.14 68.27,76.48 68.27,76.66 67.73,77.2 67.73,77.46 67.99,77.72 68.25,77.72 68.79,77.18 68.97,77.18 69.3,77.51 69.3,77.69 68.76,78.23 68.76,78.49 71.6,81.33 87.31,81.33 93.3,87.31 93.55,87.31 94.37,86.49 94.55,86.49 94.89,86.83 94.89,87.01 94.07,87.82 94.07,88.08 94.33,88.34 94.59,88.34 95.37,87.56 95.63,87.56 97.69,89.62 97.69,93.66
  BOTTOM w0.076: UC1.AU43 103.7,104.58 v1(103.56,104.58)
  BOTTOM w0.165: v1(65.15,68.68) 65.8,69.33 JDIMM1.73
DDR_CKE1_DIMMA: length 74.3
  IN1 w0.084: v1(103.54,103.28) 103.15,102.89 103.15,99.76 102.91,99.51 102.91,98.62 100.82,96.53 99.86,96.53 98.64,95.31 98.44,95.31 97.22,94.09 97.22,93.66
  IN1 w0.183: v1(66.45,60.7) 66,61.14 66,62.88 64.89,63.99 64.89,66.99 64.1,67.79 64.1,71.69 64.61,72.2 64.61,73.78 65.84,75.01 65.84,76.22 71.4,81.79 87.02,81.79 94.21,88.97 96.38,88.97 97.22,89.81 97.22,93.66
  BOTTOM w0.076: v1(103.54,103.28) 103.56,103.28 103.86,103.58 UC1.AW43
  BOTTOM w0.165: JDIMM1.74 66.1,61.8 66.01,61.7 66.01,61.14 v1(66.45,60.7)
DDR_CKE2_DIMMB: length 83.2
  IN3 w0.084: v1(101.12,101.59) 101.57,101.15 101.57,100.09 101.06,99.58 101.06,96.47 100.8,96.21 100.8,94.37 100.3,93.86 100.3,93.66
  IN3 w0.208: v1(143.32,67.2) 142.64,67.2 142.51,67.07 142.51,64.69 142.38,64.57 141.44,64.57 141.32,64.69 141.32,65.41 141.19,65.54 140.43,65.54 139.93,65.05 135.83,65.05 135.35,64.57 132.4,64.57 131.92,65.05 131.55,65.05 131.07,64.57 130.63,64.57 130.15,65.05 129.65,65.05 129.16,64.57 128.89,64.57 128.41,65.05 127.98,65.05 127.5,64.57 127.05,64.57 126.57,65.05 120.44,65.05 119.96,64.57 119.72,64.57 119.27,65.02 119.27,65.2 119.29,65.2 119.74,65.66 119.74,65.85 119.31,66.28 119.13,66.28 118.66,65.81 118.48,65.81 113.38,70.92 113.38,71.34 114.45,72.41 114.45,72.67 100.3,86.82 100.3,93.66
  BOTTOM w0.076: v1(101.12,101.59) 100.81,101.91 UC1.AY49
  BOTTOM w0.165: v1(143.32,67.2) 143.32,68.94 144.35,69.97 JDIMM2.73
DDR_CKE3_DIMMB: length 85.3
  IN3 w0.084: v1(101.18,100.99) 100.89,100.69 100.89,96.81 99.28,95.2 99.28,94.06 99.67,93.66
  IN3 w0.208: 99.67,93.66 99.67,86.78 112.45,74 112.45,73.83 111.28,72.66 111.28,72.35 111.59,72.05 111.89,72.05 113.06,73.21 113.24,73.21 113.67,72.78 113.67,72.6 112.5,71.43 112.5,71.13 119.53,64.1 143.96,64.1 144.09,64.22 144.09,65.76 143.92,65.92 143.57,65.92 v1(143.32,65.67)
  BOTTOM w0.076: UC1.AU50 99.69,104.69 99.69,102.49 v1(101.18,100.99)
  BOTTOM w0.165: v1(143.32,65.67) 144.65,64.34 JDIMM2.74
DDR_CS0_DIMMA#: length 76.1
  IN1 w0.084: 110.88,106.43 v1(110.1,106.43) ; 111.79,95.39 111.8,95.38 111.8,94.57
  IN1 w0.089: 110.88,106.43 111.58,105.73 111.58,95.6 111.79,95.39
  IN1 w0.183: 111.8,94.57 111.8,79.44 106.1,73.75 106.1,72.14 104.74,70.78 104.74,67.69 98.95,61.91 78.84,61.91 v1(77.63,60.7)
  BOTTOM w0.089: v1(110.1,106.43) 110.11,106.43 110.37,106.69 UC1.AP33
  BOTTOM w0.165: v1(77.63,60.7) 78.1,61.17 JDIMM1.114
DDR_CS1_DIMMA#: length 77.1
  IN1 w0.084: 109.61,102.12 109.61,101.93 110.83,100.72 110.83,96.52 109.5,95.19 109.5,94.57
  IN1 w0.089: 109.61,102.12 109.61,102.95 109.33,103.23 109.33,104.85 109.74,105.25 110.6,105.25 v1(111.06,105.72)
  IN1 w0.183: 109.5,94.57 109.5,80.33 103.4,74.24 103.4,72.78 100.86,70.24 100.86,67.01 99.51,65.66 97.37,65.66 97.19,65.47 97.19,64.84 97.01,64.65 96.64,64.65 96.46,64.84 96.46,65.47 96.27,65.66 94.26,65.66 94.08,65.47 94.08,64.76 93.95,64.63 93.48,64.63 93.35,64.76 93.35,65.47 93.17,65.66 91.34,65.66 91.15,65.47 91.15,64.76 91.03,64.63 90.55,64.63 90.42,64.76 90.42,65.47 90.24,65.66 82.31,65.66 81.63,66.34 81.63,67.07 81.51,67.19 v1(80.51,67.19)
  BOTTOM w0.076: UC1.AR32 111.39,106.04 v1(111.06,105.72)
  BOTTOM w0.165: v1(80.51,67.19) 81.22,67.91 81.22,69.41 80.2,70.43 JDIMM1.121
DDR_CS2_DIMMB#: length 90.5
  IN3 w0.084: v1(111.03,107.7) 111.04,107.7 111.63,107.11 111.63,101.38 111.29,101.03 111.29,96.04
  IN3 w0.208: v1(157.56,60.74) 160.28,63.46 160.28,73.56 153.98,79.85 150.02,79.85 148,81.87 120.8,81.87 111.29,91.38 111.29,96.04
  BOTTOM w0.089: UC1.AM32 111.32,107.99 v1(111.03,107.7)
  BOTTOM w0.165: JDIMM2.114 156.65,61.65 v1(157.56,60.74)
DDR_CS3_DIMMB#: length 90.3
  IN3 w0.084: 110.4,95.19 110.4,95.65 110.52,95.77 110.77,95.77 111.03,96.02 111.03,101.04 111.44,101.46 111.44,102.75 110.84,103.36 110.84,104.79 111.44,105.39 111.44,107.05 111.17,107.33 110.8,107.33 110.66,107.47 110.66,109.05 110.77,109.16 110.85,109.16 v1(111.04,108.97)
  IN3 w0.208: v1(158.96,67.2) 159.27,66.88 159.68,66.88 159.81,67.01 159.81,67.43 159.42,67.82 159.42,68.16 159.81,68.55 159.81,73.36 153.79,79.38 148.75,79.38 148.44,79.7 148.44,80.77 147.81,81.4 120.6,81.4 110.82,91.18 110.82,94.77 110.4,95.19
  BOTTOM w0.076: v1(111.04,108.97) 111.37,109.29 UC1.AK32
  BOTTOM w0.165: v1(158.96,67.2) 159.6,67.85 159.6,69.03 158.94,69.7 158.94,70.15 158.75,70.33 JDIMM2.121
DDR_PG_CTRL: length 91.1
  TOP w0.102: U2303.2 44.12,66.67 43.84,66.94 43.34,66.94 41.94,65.54 39.97,65.54 38.89,66.62 v2(38.89,71.23) 38.89,71.77 v1(39.78,72.65)
  BOTTOM w0.076: 91.12,104.56 92.15,104.56 92.16,104.57 92.44,104.57 92.5,104.51 UC1.AV61
  BOTTOM w0.089: 88.55,101.99 88.23,101.67 88.23,99.65
  BOTTOM w0.102: v1(39.78,72.65) 39.78,74.5 40.16,74.88 48.86,74.88 55.97,81.99 86.01,81.99 88.23,84.21 88.23,99.65 ; 91.12,104.56 88.55,101.99
DDR_XDP_SMBCLK_R1: length 2.9
  BOTTOM w0.102: JXDP1.53 60.2,92.15 60.29,92.06 60.29,91.2 60.1,91 RP46.7
DDR_XDP_SMBDAT_R1: length 2.9
  BOTTOM w0.102: RP46.8 60.6,91.07 60.49,91.17 60.49,91.94 60.7,92.15 JXDP1.51
DDR_XDP_WLAN_TP_SMBCLK: length 442.5
  TOP w0.102: v1(70.36,112.53) 70.35,112.52 JTP.5 ; v1(123.03,149.11) 126.97,145.17 126.97,138.44 129.1,136.31 135.63,136.31 137.69,134.25 148.44,134.25 148.77,133.92 v2(150.51,133.92) v1(151.07,134.48) 151.36,134.19 151.36,133.07 146.83,128.55 146.83,125.86 145.77,124.8 145.77,121.36 149.45,117.68 149.45,116.12 149.95,115.62 149.95,112.71 147.8,110.56 v1(146.46,110.56)
  IN2 w0.127: v1(146.46,110.56) 146.65,110.37 146.65,107.03 145.25,105.63 145.25,74.45 144.05,73.25 144.05,62.98 144.62,62.41 144.62,52.16 v1(144.87,51.9)
  IN3 w0.127: v1(199.27,162.52) 199.14,162.39 199.14,161.85 198.66,161.36 190.92,161.36 188.8,159.24 161.61,159.24 160.39,158.02 160.39,153.94 158.63,152.17 158.63,141.41 151.69,134.48 v1(151.07,134.48) ; v1(70.36,112.53) 67.4,112.53 63.44,108.57 63.44,99.62 64.87,98.19 64.87,96.83 63.9,95.86 63.9,92.24 63.31,91.65 63.31,87.04 64.01,86.33 v1(64.01,86.24) 64.59,85.67 64.59,77.91 69.34,73.15 69.34,56.19 73.71,51.83 102.94,51.83 103.27,51.5 v1(103.27,51.4) 103.94,51.4 105.58,53.04 116.61,53.04 117.32,52.33 144.45,52.33 v1(144.87,51.9) 145.04,51.74 163,51.74 163.21,51.94 171.18,51.94 171.43,52.19 176.37,52.19 176.83,52.65 177.34,52.65 179.09,54.4 180.7,54.4 181.77,55.47 183.38,55.47 184.58,56.66 187.24,56.66 187.79,57.21 187.79,60.05 186.76,61.08 186.15,61.08 185.87,61.36 185.87,61.65 v1(186.33,62.12)
  BOTTOM w0.102: v1(103.27,51.4) 103.27,57.08 104.3,58.12 104.3,61.93 104.5,62.13 JDIMM1.202 ; JDIMM2.202 183.05,61.85 183.67,61.22 185.44,61.22 v1(186.33,62.12) ; v1(123.03,149.11) 123.03,148.13 120.43,145.53 109.4,145.53 108.1,146.83 JMINI.30 ; RX6.1 199.33,162.58 v1(199.27,162.52) ; R2332.2 146.97,110.06 v1(146.46,110.56) 144.87,110.56 144.74,110.43 QC1.1 ; RP46.2 60.1,86.25 60.54,85.8 63.57,85.8 v1(64.01,86.24)
DDR_XDP_WLAN_TP_SMBDAT: length 446.6
  TOP w0.102: v1(70.94,113) 71.35,112.59 JTP.6 ; v1(123.03,149.74) 123.47,149.3 123.47,148.99 127.19,145.27 127.19,138.53 129.19,136.54 135.73,136.54 137.79,134.48 148.59,134.48 148.87,134.2 150.03,134.2 v1(150.42,134.59) 150.82,134.99 151.29,134.99 151.59,134.68 151.59,132.98 147.06,128.45 147.06,125.77 146,124.71 146,121.45 149.68,117.77 149.68,116.21 v2(150.79,115.11) 151.64,114.25 151.64,108.48 151.25,108.09 146.78,108.09 v1(146.21,107.52)
  IN2 w0.127: v1(146.21,107.52) 146.21,106.94 145,105.74 145,74.56 143.79,73.35 143.79,62.88 144.36,62.3 144.36,52.16 v1(144.11,51.91)
  IN3 w0.127: v1(70.94,113) 66.62,113 63.19,109.57 63.19,99.51 64.61,98.09 64.61,96.94 63.64,95.97 63.64,92.35 63.05,91.76 63.05,86.62 v1(63.43,86.24) 63.43,86.15 64.32,85.25 64.32,77.8 69.08,73.04 69.08,56.09 73.77,51.4 v1(102.68,51.4) 102.68,51.35 103.06,50.96 103.93,50.96 105.59,52.63 116.66,52.63 117.3,51.99 139.59,51.99 140.1,51.48 143.69,51.48 v1(144.11,51.91) 144.54,51.48 163.11,51.48 163.31,51.69 171.29,51.69 171.54,51.94 176.48,51.94 176.94,52.4 177.45,52.4 179.19,54.14 180.81,54.14 181.87,55.21 183.49,55.21 184.68,56.4 187.35,56.4 188.05,57.1 188.05,60.36 186.91,61.5 v1(186.32,61.5) ; v1(198.63,162.52) 198.63,162.51 198.89,162.25 198.89,161.95 198.55,161.62 190.82,161.62 188.7,159.5 161.51,159.5 160.14,158.13 160.14,154.04 158.37,152.28 158.37,141.52 151.83,134.97 150.8,134.97 v1(150.42,134.59)
  BOTTOM w0.102: v1(198.63,162.52) 198.45,162.7 RX31.1 ; QC1.4 146.04,107.68 v1(146.21,107.52) 146.47,107.52 R2331.2 ; v1(63.43,86.24) 60.74,86.24 60.35,86.63 60.35,88.22 60.6,88.47 RP46.1 ; JDIMM2.200 182.45,62.08 183.62,60.91 185.72,60.91 v1(186.32,61.5) ; JMINI.32 108.9,146.6 109.74,145.76 119.04,145.76 v1(123.03,149.74) ; JDIMM1.200 103.9,62.15 104.08,61.97 104.08,58.22 102.68,56.82 v1(102.68,51.4)
DEVSLP0: length 143.4
  TOP w0.089: v1(132.23,118.53) 132.02,118.31 RC11.1
  TOP w0.102: v1(193.35,49.31) 193.95,49.31 194.47,48.79 195.11,48.79 196.31,50 196.64,50 197.39,50.75 199.81,50.75 200.69,49.87 v2(202.73,49.87) 207.42,49.87 209.44,51.89 209.44,52.61 210,53.17 214.43,53.17 215.17,53.91 215.17,58.05 RS8.1
  IN1 w0.084: 137.53,120.59 136.85,120.59 135.33,119.07 132.78,119.07 v1(132.23,118.53)
  IN1 w0.127: v1(193.35,49.31) 192.92,49.74 192.92,50.35 193.07,50.49 193.07,54.51 192.37,55.2 192.37,56.23 190.88,57.72 190.88,64.76 189.81,65.83 189.81,75.87 182.91,82.77 178.89,82.77 173.85,87.8 169.48,87.8 154.72,102.56 154.72,104.39 153.64,105.46 153.64,108.26 149.81,112.09 149.25,112.09 147.9,113.45 147.9,114.18 145.52,116.56 145.52,118.34 143.27,120.59 137.53,120.59
  BOTTOM w0.076: UC1.P2 130.08,118.05 131.11,118.05 131.59,118.53 v1(132.23,118.53)
DGPU_HOLD_RST#: length 41.4
  TOP w0.089: v1(128.68,117.93) 128.68,118.43 RC77.2
  IN1 w0.084: 137.3,120.84 136.29,120.84 135.04,119.59 131.9,119.59 131.07,118.76 129.44,118.76 128.68,117.99 128.68,117.93 v1(128.68,117.93)
  IN1 w0.127: v1(153.1,110.31) 152.67,110.31 150.13,112.85 149.57,112.85 148.7,113.72 148.7,115.63 143.49,120.84 137.3,120.84
  IN3 w0.127: v1(158.82,108.4) 158.38,108.85 156.75,108.85 155.29,110.31 v1(153.1,110.31)
  BOTTOM w0.089: UC1.N4 128.33,118.28 128.61,118 v1(128.68,117.93)
  BOTTOM w0.102: v2(159.6,108) 159.2,108.4 v1(158.82,108.4) 158.65,108.4 158.31,108.75 158.31,109.02 158.38,109.09 UV13.1
DGPU_PRSNT#: length 13.4
  TOP w0.089: RC99.1 134.37,115.89 RC100.2 135.08,117.54 v1(135.22,117.68) 135.66,117.68 v2(135.76,117.78)
  IN3 w0.084: v1(135.22,117.68) 134.74,118.16 130.56,118.16 129.95,117.55 128.11,117.55 127.92,117.36 126.44,117.36 v1(126.02,117.78)
  BOTTOM w0.089: UC1.R7 126.34,117.45 v1(126.02,117.78)
DGPU_PWROK: length 169.5
  TOP w0.102: UE1.18 189.99,36.71 189.92,36.78 189.92,37.19 v1(190.33,37.59)
  IN1 w0.127: v1(209.77,43.86) 209,44.64 v1(209,53.55) ; v1(136.81,116.72) 138.47,116.72 140.66,118.91 143.27,118.91 143.59,118.59 143.59,117.59 147.39,113.79 147.39,113.23 149.04,111.58 149.6,111.58 153.14,108.05 153.14,105.25 154.21,104.18 154.21,102.35 165.32,91.24 165.32,88.56 167.53,86.34 174.23,86.34 178.57,82 182.59,82 189.04,75.55 189.04,65.52 190.12,64.44 190.12,57.4 190.99,56.53 190.99,54.74 191.72,54.01 191.72,50.74 192.16,50.3 192.16,47.65 191.83,47.32 191.83,45.04 192.17,44.7 192.17,39.43 v1(190.33,37.59)
  IN3 w0.084: v1(136.81,116.72) 136.58,116.95 134.17,116.95 133.62,117.5 132,117.5 130.52,116.02 128.48,116.02 128.07,116.43 127.55,116.43 127.47,116.36 127.09,116.36 126.63,115.9 v1(126.52,115.9)
  BOTTOM w0.089: UC1.U6 126.99,116.37 v1(126.52,115.9) ; v1(136.81,116.72) 137.13,117.04 RC73.2
  BOTTOM w0.102: v1(190.33,37.59) 190.33,38.82 v2(191.08,39.57) 195.61,44.1 202.3,44.1 202.88,43.52 209.43,43.52 v1(209.77,43.86)
  BOTTOM w0.203: PU800.2 206.19,54.91 206.66,54.44
  BOTTOM w0.254: v1(209,53.55) PR808.2 208.64,54.24 208.44,54.44 206.66,54.44
DH_1.35V: length 4.7
  TOP w1.016: 154.79,23.39 153.38,21.99 153.38,19.31
  vias: v2(155.28,24.3) v3(153.13,18.37) v3(153.77,18.37) v3(155.74,23.77) v3(156.12,24.28)
DH_CHG: length 15.7
  TOP w0.102: v2(145.95,170.62) 145.99,170.58 145.99,169.95
  IN1 w1.016: 146.84,169.24 150.46,169.24 ; 152.56,169.24 152.94,169.62 163.8,169.62
  vias: v1(145.22,169.5) v1(145.22,168.87) v1(151.54,169.56) v1(151.54,168.92) v1(164.74,169.3) v1(165.32,169.3)
DISPOFF#: length 8.9
  BOTTOM w0.102: DX1.1 219.42,166.62 RX9.1 v2(219.82,168.54) 219.82,169.32 220.31,169.82 220.94,171.39 222.45,172.9 JLVDS.37
DL_1.35V: length 8
  IN3 w1.016: 157.06,12.9 157.52,13.35 157.52,20.03
  BOTTOM w0.102: v2(157.49,21.1) 157.45,21.14 v3(157.45,21.8)
  vias: v1(156.73,11.92) v1(157.32,11.92) v3(157.45,22.44)
DL_CHG: length 5.4
  TOP w1.016: 166.15,173.17 165.26,174.06 164.05,174.06 162.97,175.14 161.57,175.14
  vias: v2(160.96,175.49)
DP_HPD: length 38.6
  TOP w0.102: Q1.1 40.36,116.71 R15.1 39.91,118.18 R17.2 39.96,118.79 v1(40.1,118.93)
  IN3 w0.127: v1(40.1,118.93) 40.1,118.55 40.48,118.17 40.48,114.17 39.65,113.35 39.65,106.23 36.48,103.06 30.36,103.06 26.74,99.44 23.97,99.44 23.61,99.8 v1(23.61,100.58)
  BOTTOM w0.102: v1(23.61,100.58) 23.25,100.22 U4.44 ; v2(40.1,118.27) v1(40.1,118.93)
DPB_HPD: length 187.4
  TOP w0.102: Q1.3 41.43,117.68 R17.1 40.87,118.74 v1(40.68,118.93) ; v1(36.1,92.64) v2(35.41,92.64)
  IN2 w0.089: v1(127.28,127.84) 130.08,125.04 130.08,119.19 131.6,117.67 131.6,116.79 133.19,115.19 133.19,114.79 132.73,114.33 130.41,114.33 129.87,113.79 129.87,111.47 129.74,111.34 129.74,102.52 130.11,102.15 130.11,100.68 129.83,100.4 128.24,100.4 124.68,96.85 123.91,96.85 120.67,93.61
  IN2 w0.127: v1(36.1,92.64) 42.57,86.17 42.57,76.15 43.65,75.07 47.67,75.07 58.15,85.54 112.6,85.54 120.67,93.61
  IN3 w0.127: v1(36.1,92.64) 36.1,102.32 40.03,106.25 40.03,113.16 40.8,113.92 40.8,118.82 v1(40.68,118.93)
  BOTTOM w0.076: UC1.C8 125.87,124.49 125.87,125.04 126.03,125.2 126.03,125.92 126.27,126.16 126.43,126.16 127.28,127.01 v1(127.28,127.84)
DPC_HPD: length 10.7
  BOTTOM w0.076: 130.05,132.57 129.53,132.57 129.19,132.24 129.14,132.24 128.93,132.03 128.93,130.08 126.91,128.06 126.91,127.04 125.74,125.86 UC1.A8
  BOTTOM w0.089: 130.38,133.14 v2(130.38,132.9) 130.05,132.57
  BOTTOM w0.102: RC84.2 130.38,133.67 130.38,133.14
DPLL_PVSS: length 3.8
  TOP w0.254: RV248.2 167.94,108.39 RV247.2 168.44,108.91 v2(168.91,108.91) 169.14,108.91 169.68,108.37 v1(169.68,108.28)
  BOTTOM w0.254: v1(169.68,108.28) 169.27,108.69 UV1.AN32
DQA0_0: length 15.5
  TOP w0.102: v1(166.59,132.66) 166.21,133.04 166.21,134.83 165.65,135.39 ; UV5.U11 161.88,144.45
  TOP w0.127: 161.88,144.45 161.62,144.18 161.28,143.84 161.28,139.76 v2(164.09,136.94) 165.65,135.39
  BOTTOM w0.102: v1(166.59,132.66) 166.22,132.29 UV1.C37
DQA0_1: length 18.3
  TOP w0.102: v1(166.59,131.84) 166.59,131.96 165.26,133.3 v2(165.26,134.68) 165.26,135.24 165.11,135.39 ; UV5.T11 162.68,145.25
  TOP w0.127: 165.11,135.39 160.79,139.7 160.79,144.18 161.86,145.25 162.68,145.25
  BOTTOM w0.127: v1(166.59,131.84) 166.97,132.22 166.97,132.3 UV1.C35
DQA0_2: length 12.7
  TOP w0.102: v1(166.59,133.42) v2(166.59,134.31) 166.59,134.98 166.19,135.39
  TOP w0.127: UV5.U13 162.22,143.25 161.66,142.68 161.66,139.92 166.19,135.39
  BOTTOM w0.102: v1(166.59,133.42) 166.92,133.09 UV1.A35
DQA0_3: length 15
  TOP w0.127: v1(167.42,132.53) 167.42,132.66 167.03,133.04 167.03,135.08 v2(163.52,138.6) 162.68,139.43 162.68,140.92 161.89,141.72 161.89,142.59 162.14,142.85 162.68,142.85 UV5.T13
  BOTTOM w0.127: v1(167.42,132.53) 167.42,131.94 UV1.E34
DQA0_4: length 18
  TOP w0.102: 169.96,135.39 v2(169.96,134.99) 169.96,134.38 169.64,134.06 169.64,133.73 170.14,133.23 170.14,130.87 v1(169.66,130.4) ; UV5.M11 166.28,144.85 166.68,144.45
  TOP w0.127: 166.68,144.45 166.68,143.97 167.01,143.65 167.28,143.65 167.48,143.45 167.48,140.24 166.72,139.48 166.72,138.63 169.96,135.39 169.96,135.39
  BOTTOM w0.102: UV1.G32 169.26,130 v1(169.66,130.4)
DQA0_5: length 17
  TOP w0.102: UV5.N11 165.08,144.45 ; v1(168.39,131.41) 168.5,131.52 169.3,131.52 169.53,131.74 169.53,132.98 168.94,133.57 168.94,134.79 168.35,135.39
  TOP w0.127: 168.35,135.39 v2(166.42,137.31) 165.08,138.65 165.08,144.45
  BOTTOM w0.102: UV1.D33 168.66,131.68 v1(168.39,131.41)
DQA0_6: length 14.8
  TOP w0.102: 166.68,142.85 166.28,143.25 UV5.M13 ; v1(169.64,131.01) 169.93,131.31 169.93,133.15 169.38,133.7 169.38,134.31 169.52,134.45 169.52,135.29 169.42,135.39
  TOP w0.127: 169.42,135.39 v2(168.06,136.75) 166.27,138.54 166.27,139.79 166.68,140.21 166.68,142.85
  BOTTOM w0.102: UV1.F32 169.32,130.69 v1(169.64,131.01)
DQA0_7: length 15
  TOP w0.102: 168.88,135.39 169.14,135.13 169.14,133.65 169.73,133.06 169.73,131.66 169.19,131.12 v1(168.97,131.12) ; 165.88,142.85 165.48,143.25 UV5.N13
  TOP w0.127: 168.88,135.39 165.88,138.39 v2(165.88,138.71) 165.88,142.85
  BOTTOM w0.102: UV1.E32 169.35,131.49 v1(168.97,131.12)
DQA0_8: length 42.8
  BOTTOM w0.102: 168.79,133.82 169.19,133.42 169.57,133.42 169.77,133.22 169.77,132.96 169.75,132.95 169.75,132.4 UV1.D31
  BOTTOM w0.127: UV4.F4 166.74,150.9 166.74,153.81 165.4,155.14 160.83,155.14 158.38,152.69 v2(158.38,151.67) 158.38,138.49 160.46,136.41 162.97,136.41 165.45,133.93 165.9,133.93 166.02,133.82 168.79,133.82
DQA0_9: length 40.5
  BOTTOM w0.102: 164.53,135.39 165.77,134.15 169.12,134.15 169.97,133.3 169.97,132.88 169.96,132.86 169.96,132.52 170.18,132.29 170.34,132.29 170.59,132.04 170.59,131.26 170.86,130.99 UV1.F30
  BOTTOM w0.127: 164.53,135.39 163.06,136.85 160.56,136.85 158.91,138.5 v2(158.91,149.69) 158.91,152.66 161,154.76 164.75,154.76 165.94,153.57 165.94,152.4 UV4.F2
DQA0_10: length 37.6
  BOTTOM w0.102: 170.59,133.91 170.59,132.76 UV1.C30
  BOTTOM w0.127: 170.59,133.91 170.14,134.36 166.09,134.36 163.1,137.36 160.62,137.36 159.29,138.69 v2(159.29,147.78) 159.29,152.41 161.26,154.38 164.45,154.38 165.08,153.76 165.08,152.45 UV4.E2
DQA0_11: length 36.5
  BOTTOM w0.127: UV4.E4 165.07,150.87 165.07,152.14 164.8,152.41 164.56,152.41 164.29,152.68 164.29,153.7 163.99,154 161.7,154 v2(160.34,152.64) 159.81,152.11 159.81,139.15 160.88,138.08 162.97,138.08 166.46,134.59 170.37,134.59 170.84,134.13 170.84,133.32 UV1.A30
DQA0_12: length 30.3
  BOTTOM w0.102: 171.42,134.66 172.18,133.89 172.18,133.09 172.37,132.9 172.37,132.48 172.22,132.33 172.22,130.93 UV1.F28
  BOTTOM w0.127: UV4.A2 161.93,151.69 161.42,151.69 160.96,151.22 160.96,139.91 161.65,139.22 v2(162.13,139.22) 164.38,139.22 167.77,135.84 170.45,135.84 171.42,134.87 171.42,134.66
DQA0_13: length 27.5
  BOTTOM w0.102: 172.18,134.71 172.66,134.23 172.66,133.53 172.97,133.22 172.97,132.96 172.66,132.66 UV1.C28
  BOTTOM w0.127: UV4.A4 161.9,150.45 161.72,150.27 161.72,140.23 161.96,139.99 162.3,139.99 162.43,140.11 162.43,140.49 162.55,140.62 162.81,140.62 162.93,140.49 162.93,140.11 163.06,139.99 164.69,139.99 v2(167.59,137.1) 168.08,136.6 170.77,136.6 172.18,135.19 172.18,134.71
DQA0_14: length 27.9
  BOTTOM w0.127: UV1.A28 172.44,133.31 172.44,134.12 171.8,134.77 171.8,135.03 170.61,136.22 167.92,136.22 v2(165.1,139.04) 164.54,139.61 161.8,139.61 161.34,140.07 161.34,150.33 161.83,150.82 162.4,150.82 162.65,151.08 162.65,151.62 UV4.B2
DQA0_15: length 28.4
  BOTTOM w0.102: 172.56,134.69 172.56,134.63 172.86,134.33 172.86,133.61 173.17,133.3 173.17,132.88 172.97,132.68 172.97,131.79 UV1.E28
  BOTTOM w0.127: 172.56,134.69 172.56,135.35 170.93,136.98 v2(169.48,136.98) 168.24,136.98 164.85,140.37 164.52,140.37 164.4,140.49 164.4,140.85 164.27,140.98 164.02,140.98 163.89,140.85 163.89,140.49 163.76,140.37 163.44,140.37 163.32,140.49 163.32,140.87 163.19,141 162.46,141 161.95,141.5 161.95,149.86 162.14,150.06 162.7,150.06 UV4.B4
DQA0_16: length 24
  TOP w0.127: UV5.B2 174.72,151.61 175.22,151.61 175.53,151.3 176,151.3 176.17,151.13 176.17,150.3 176.31,150.17 176.31,149.09 177.27,148.13 177.27,139.91 173.64,136.27 v2(173.64,135.53) 173.64,134.97 v1(173.19,134.52)
  BOTTOM w0.102: v1(173.19,134.52) 173.75,133.96 173.75,132.83 173.77,132.82 173.77,132.56 173.77,132.56 173.77,132.19 UV1.D27
DQA0_17: length 24.9
  TOP w0.127: v1(173.51,131.33) 174.15,131.97 v2(174.15,133.75) 174.15,136.24 177.65,139.75 177.65,148.28 176.69,149.25 176.69,150.32 176.55,150.46 176.55,151.42 176.2,151.77 175.57,151.77 175.29,152.05 UV5.A2
  BOTTOM w0.102: UV1.F26 174.06,130.78 v1(173.51,131.33)
DQA0_18: length 21.8
  TOP w0.127: v1(173.19,135.2) 172.88,135.2 172.69,135.39 172.69,136.43 174.76,138.5 v2(174.76,138.95) 174.76,139.33 176.51,141.09 176.51,147.81 175.5,148.82 175.5,149.76 175.18,150.08 174.66,150.08 UV5.B4
  BOTTOM w0.102: v1(173.19,135.2) 173.96,134.44 173.96,132.9 174.26,132.59 UV1.C26
DQA0_19: length 21.5
  TOP w0.127: v1(173.19,135.84) 173.19,136.36 v2(173.98,137.15) 176.14,139.31 176.14,139.49 175.89,139.75 175.89,139.93 176.07,140.11 176.25,140.11 176.5,139.85 176.68,139.85 176.86,140.03 176.86,140.21 176.61,140.46 176.61,140.64 176.89,140.93 176.89,147.97 175.92,148.94 175.92,150.01 175.48,150.45 UV5.A4
  BOTTOM w0.127: UV1.A26 174.19,133.16 174.19,134.79 173.19,135.79 v1(173.19,135.84)
DQA0_20: length 38.5
  TOP w0.127: v1(175.29,131.35) 175.29,132.73 v2(179.94,137.38) 179.94,152.36 176.87,155.42 172.22,155.42 170.82,154.02 170.82,153.71 170.64,153.52 170.64,150.9 UV5.F4
  BOTTOM w0.102: UV1.F24 175.66,130.98 v1(175.29,131.35)
DQA0_21: length 32.4
  TOP w0.102: v1(175.16,135.01) 175.54,135.39
  TOP w0.127: UV5.E4 172.34,150.9 172.34,152.2 172.59,152.45 172.88,152.45 173.14,152.71 173.14,153.71 173.47,154.04 176.64,154.04 178.8,151.88 178.8,138.65 v2(175.95,135.8) 175.54,135.39
  BOTTOM w0.102: v1(175.16,135.01) 175.16,135.07 176.17,134.07 176.17,132.94 175.86,132.64 UV1.C24
DQA0_22: length 31.3
  TOP w0.127: UV5.E2 171.89,152.18 172.32,152.62 172.32,153.85 173.05,154.57 176.64,154.57 179.18,152.04 179.18,138.26 v2(177.84,136.92) 175.35,134.43 v1(175.17,134.43)
  BOTTOM w0.127: UV1.A24 175.86,134.02 175.45,134.43 v1(175.17,134.43)
DQA0_23: length 34.9
  TOP w0.127: v1(175.19,133.84) 175.58,133.84 179.56,137.82 179.56,152.2 v2(178.69,153.07) 176.71,155.04 172.38,155.04 171.51,154.17 171.51,152.47 UV5.F2
  BOTTOM w0.102: v1(175.19,133.84) 175.57,133.46 175.57,133.23 175.56,133.22 175.56,131.79 UV1.E24
