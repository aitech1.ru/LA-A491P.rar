# Allegro board LAA491PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAB1_2: length 28.2
  TOP w0.102: UV9.K11 v1(207.37,113.11)
  IN3 w0.102: v1(189.13,116.41) 189.51,116.79 190.15,116.79 190.79,116.14 191.63,116.14 192.99,114.78 194.39,114.78 ; 203.47,114.75 203.71,114.75 203.74,114.73 206.81,114.73 207.23,114.31 207.61,114.31 207.74,114.18 207.74,113.73 207.37,113.37 v1(207.37,113.11)
  IN3 w0.157: 194.39,114.78 195.39,114.78 197.03,113.15 198.73,113.15 198.85,113.27 198.85,114.08 198.98,114.2 199.36,114.2 199.48,114.08 199.48,113.27 199.61,113.15 199.99,113.15 200.11,113.27 200.11,114.63 200.24,114.76 200.62,114.76 200.74,114.63 200.74,114.31 200.87,114.18 201.26,114.18 201.39,114.31 201.39,115.07 201.51,115.2 203.03,115.2 203.47,114.75
  BOTTOM w0.102: UV1.AC8 188.86,116.65 189.11,116.41 v1(189.13,116.41) ; UV9.K11 v1(207.37,113.11)
MAB1_3: length 36.5
  TOP w0.102: v1(207.36,113.89) 207.74,113.51 UV9.K10
  IN3 w0.102: v1(207.36,113.89) 207.27,113.89 206.87,114.29 204.52,114.29 204.16,113.93 203.47,113.93 ; v1(188.46,116.39) 188.9,115.94 191.47,115.94 192.42,114.99 192.42,114.53 193.45,113.5 194.39,113.5
  IN3 w0.157: 194.39,113.5 195.99,113.5 196.83,112.66 197.29,112.66 197.45,112.5 197.45,109.99 197.58,109.87 197.95,109.87 198.08,109.99 198.08,112.5 198.24,112.66 198.55,112.66 198.71,112.5 198.71,110.37 198.84,110.25 199.21,110.25 199.34,110.37 199.34,112.5 199.5,112.66 200.59,112.66 200.75,112.82 200.75,113.57 200.88,113.7 201.25,113.7 201.38,113.57 201.38,112.88 201.51,112.75 201.9,112.75 202.02,112.88 202.02,113.77 202.31,114.06 202.31,114.58 202.44,114.71 202.81,114.71 202.94,114.58 202.94,114.09 203.1,113.93 203.47,113.93
  BOTTOM w0.102: UV9.K10 207.74,113.51 v1(207.36,113.89) ; v1(188.46,116.39) 188.46,116.5 UV1.AC9
MAB1_4: length 28.6
  TOP w0.102: v1(207.37,112.31) 206.97,111.91 UV9.H11
  IN3 w0.102: 194.39,115.81 193.38,115.81 192.21,116.98 190.3,116.98 v1(189.93,117.35) ; 203.47,115.53 204.98,115.53 205.42,115.09 207.53,115.09 207.77,114.85 207.77,114.61 207.94,114.44 207.94,113.4 207.79,113.24 207.79,112.73 v1(207.37,112.31)
  IN3 w0.157: 203.47,115.53 203.32,115.68 199.75,115.68 199.63,115.56 199.63,114.82 199.5,114.69 199.12,114.69 199,114.82 199,115.56 198.87,115.68 198.49,115.68 198.37,115.56 198.37,113.76 198.24,113.63 197.23,113.63 195.99,114.88 195.99,115.58 195.76,115.81 194.39,115.81
  BOTTOM w0.102: UV1.AA7 189.93,117.82 v1(189.93,117.35) ; v1(207.37,112.31) 206.97,111.91 UV9.H11
MAB1_5: length 29.7
  TOP w0.102: UV9.H10 207.77,111.91 v1(208.17,112.31)
  IN3 w0.102: v1(189.26,117.35) 189.64,117.73 190.09,117.73 190.59,117.23 192.25,117.23 193.18,116.3 194.39,116.3 ; 203.47,116.17 203.63,116.17 203.75,116.29 207.65,116.29 208.05,115.89 208.33,115.89 208.55,115.67 208.55,112.69 v1(208.17,112.31)
  IN3 w0.157: 194.39,116.3 197.12,116.3 197.25,116.17 197.25,114.31 197.38,114.18 197.75,114.18 197.88,114.31 197.88,116.01 198.04,116.17 203.47,116.17
  BOTTOM w0.102: UV1.AA8 188.86,118.09 189.26,117.69 v1(189.26,117.35) ; v1(208.17,112.31) 207.77,111.91 UV9.H10
MAB1_6: length 30.9
  TOP w0.102: UV9.H5 211.45,111.59 v1(210.47,111.59)
  IN3 w0.102: 203.47,117.86 203.55,117.93 205.24,117.93 205.83,117.34 206.26,117.34 206.41,117.49 208.46,117.49 209.5,116.45 209.5,112.55 v1(210.47,111.59) ; v1(189.2,118.52) 189.2,118.51 189.58,118.14 190.26,118.14 190.76,117.64 192.77,117.64 193.13,117.28 194.39,117.28
  IN3 w0.157: 203.47,117.86 202.89,117.28 194.39,117.28
  BOTTOM w0.102: v1(189.2,118.52) 189.2,118.95 UV1.Y8 ; v1(210.47,111.59) 211.45,111.59 UV9.H5
MAB1_7: length 31.4
  TOP w0.102: v1(212.19,111.51) 212.57,111.89 UV9.H4
  IN3 w0.102: v1(188.57,117.39) 189.11,117.94 190.17,117.94 190.67,117.43 192.5,117.43 193.15,116.79 194.39,116.79 ; 203.47,117.13 204.13,117.13 204.56,116.69 208.33,116.69 209.3,115.72 209.3,111.91 210.08,111.13 211.8,111.13 v1(212.19,111.51)
  IN3 w0.157: 194.39,116.79 203.1,116.79 203.44,117.13 203.47,117.13
  BOTTOM w0.102: UV9.H4 212.57,111.89 v1(212.19,111.51) ; v1(188.57,117.39) 188.06,117.89 UV1.AA9
MAB1_8: length 31.7
  TOP w0.102: v1(212.22,112.33) 211.84,112.71 UV9.J5
  IN3 w0.102: v1(189.24,119.74) 189.62,119.35 190.31,119.35 190.53,119.14 191.3,119.14 191.51,119.35 191.99,119.35 192.27,119.07 193.07,119.07 193.4,118.74 194.39,118.74 ; v1(212.22,112.33) 212.22,112.76 210.2,114.78 210.2,118.24 208.67,119.78
  IN3 w0.157: 208.67,119.78 208.46,119.99 203.27,119.99 202.02,118.74 194.39,118.74
  BOTTOM w0.102: UV1.W8 189.24,120.12 v1(189.24,119.74) ; v1(212.22,112.33) 211.84,112.71 UV9.J5
MCT0: length 3.4
  TOP w0.102: RL19.1 v2(22.19,91.6)
  TOP w0.508: RL19.1 21.5,90.31 v1(21.49,90.3)
  BOTTOM w0.508: v1(21.49,90.3) TL2.22
MCT1: length 3.6
  TOP w0.102: RL20.1 v2(22.19,87.59)
  TOP w0.508: v1(21.49,89.03) RL20.1
  BOTTOM w0.508: v1(21.49,89.03) TL2.21
MCT2: length 3.5
  TOP w0.102: RL39.1 v2(22.19,84.01)
  TOP w0.508: v1(21.49,82.68) RL39.1
  BOTTOM w0.508: v1(21.49,82.68) TL2.16
MCT3: length 2.8
  TOP w0.102: v1(21.49,81.41) v2(20.83,81.41)
  TOP w0.508: RL40.1 v1(21.49,81.41)
  BOTTOM w0.508: v1(21.49,81.41) TL2.15
MCURSTN: length 2.9
  BOTTOM w0.102: U4.53 19.65,99.03 18.96,98.34 R19.2 18.89,97.74 C90.2
MDI0+: length 8.3
  BOTTOM w0.102: 34.01,82.5 32.03,80.52 32.03,79.88 31.45,79.3 31.02,79.3 30.59,78.87 TL2.12 ; 34.01,82.5 34.19,82.68 34.9,82.68 35.09,82.87 35.67,82.87 UL1.1 ; 34.01,82.5 v2(34.01,82.49)
MDI0-: length 8.3
  BOTTOM w0.102: TL2.11 30.59,80.14 31.02,79.7 31.28,79.7 31.63,80.05 31.63,80.69 v2(31.9,80.97) 34.02,83.08 34.73,83.08 34.92,83.27 UL1.2
MDI1+: length 6.6
  BOTTOM w0.102: UL1.4 v2(31.97,84.07) 31.71,84.07 31.41,84.38 31.02,84.38 30.59,83.95 TL2.8
MDI1-: length 6.6
  BOTTOM w0.102: TL2.7 30.59,85.22 31.02,84.78 31.58,84.78 31.88,84.48 v2(33.81,84.48) 35.14,84.48 35.15,84.47 UL1.5
MDI2+: length 7.3
  BOTTOM w0.102: UL1.6 34.97,84.87 33.36,86.48 32.93,86.92 v2(31.65,86.92) 31.02,86.92 30.59,86.49 TL2.6
MDI2-: length 7.3
  BOTTOM w0.102: TL2.5 30.59,87.76 31.02,87.32 33.1,87.32 v2(33.65,86.77) 35.14,85.28 35.67,85.28 UL1.7
MDI3+: length 11.7
  BOTTOM w0.102: UL1.9 36.35,86.74 34.83,88.26 v2(34.83,89.41) 34.83,90.55 33.41,91.97 32.95,92.43 30.93,92.43 30.76,92.26 30.76,91.74 30.59,91.57 TL2.2
MDI3-: length 11.7
  BOTTOM w0.102: UL1.10 36.75,86.92 35.23,88.43 35.23,90.72 33.12,92.84 v2(32.54,92.84) TL2.1
MDO0+: length 5.2
  BOTTOM w0.102: JLAN.1 16.35,79.23 16.71,78.86 v1(16.87,78.86) 18.76,78.86 18.76,78.87 TL2.13
MDO0-: length 5.2
  BOTTOM w0.102: TL2.14 18.87,80.14 18.77,80.03 v1(18.77,79.54) 18.77,79.44 18.6,79.27 16.88,79.27 16.1,80.05 JLAN.2
MDO1+: length 7
  BOTTOM w0.102: TL2.17 18.89,83.95 18.76,84.07 18.07,84.07 17.87,83.88 v1(17.87,82.61) 17.47,82.21 17.21,82.21 16.28,81.27 JLAN.3
MDO1-: length 7
  BOTTOM w0.102: TL2.18 18.95,85.22 v1(18.48,84.74) 18.22,84.48 17.9,84.48 17.47,84.05 17.47,82.78 17.3,82.61 16.98,82.61 16.1,83.49 JLAN.6
MDO2+: length 8.4
  IN3 w0.102: JLAN.4 15.91,82.48 15.91,82.99 16.12,83.2 16.62,83.2 17.48,84.06 17.48,86.68 17.87,87.07 18.49,87.07 v1(18.7,86.87)
  BOTTOM w0.102: TL2.19 19.08,86.49 v1(18.7,86.87)
MDO2-: length 8.4
  IN3 w0.102: v1(18.7,87.45) 18.62,87.37 17.75,87.37 17.17,86.8 17.17,84.19 16.49,83.5 15.99,83.5 15.8,83.31 JLAN.5
  BOTTOM w0.102: TL2.20 19,87.76 v1(18.7,87.45)
MDO3+: length 11.1
  BOTTOM w0.102: JLAN.7 15.88,85.35 16.07,85.16 16.87,85.16 17.58,85.87 v1(17.58,89.27) 17.58,91.4 17.87,91.69 18.63,91.69 18.76,91.57 TL2.23
MDO3-: length 11.1
  BOTTOM w0.102: JLAN.8 16.1,85.71 16.24,85.57 16.7,85.57 17.17,86.04 v1(17.17,91.57) 17.7,92.1 18.41,92.1 18.6,92.29 18.6,92.67 18.76,92.84 TL2.24
ME_EN: length 89.1
  TOP w0.102: UE1.99 180.16,48.91 180.16,48.91 RE326.1 179.42,48.91 178.96,48.45 178.05,48.45 v1(177.96,48.54)
  IN1 w0.127: v1(139.28,93.1) 139.67,93.1 155.24,77.53 157.27,77.53 159.65,75.15 169.28,75.15 173.17,71.26 173.17,64.3 173.98,63.49 173.98,60.42 176.37,58.04 176.37,48.97 177.19,48.14 177.56,48.14 v1(177.96,48.54)
  BOTTOM w0.089: RC8.1 126.34,94.68 126.8,94.22
  BOTTOM w0.102: v1(139.28,93.1) 139.28,93.04 138.64,92.39 v2(130.8,92.39) 130.28,92.39 128.53,94.14 126.88,94.14 126.8,94.22
ME_SUS_PWR_ACK: length 111.5
  TOP w0.102: v1(198.53,38.68) 198.53,37.98 198.25,37.71 UE1.34 ; v1(179.04,46.91) 178.34,46.91 176.17,49.08 176.17,56.16 175.06,57.27 175.06,71.28 174.62,71.72 174.62,78.39 167.87,85.14 167.87,89.09 164.86,92.1 157.08,92.1 156.81,91.83 155.22,91.83 151.7,95.36 v2(142.66,95.36) 136.65,95.36 135.91,96.1 RC27.2 RC42.1
  IN3 w0.127: v1(198.53,38.68) 198.26,38.68 197.37,39.57 197.37,41.77 193.31,45.84 190.57,45.84 189.91,46.5 188.34,46.5 187.08,45.24 184.95,45.24 184.19,44.47 182.05,44.47 180.05,46.47 179.48,46.47 v1(179.04,46.91)
ME_SUS_PWR_ACK_R: length 11.2
  TOP w0.089: v1(131.6,101.54) 131.6,101.44
  TOP w0.102: 131.6,101.44 131.6,99.78 v2(133.02,98.36) RC35.1 RC42.2
  BOTTOM w0.076: UC1.AV4 128.63,103.93 128.63,103.46 128.68,103.4 128.68,102.79 129.25,102.22 130.55,102.22 131.23,101.54 v1(131.6,101.54)
MECH#1: length 3.5
  BOTTOM w0.102: T82.1 162.46,134.05 164.3,134.05 UV1.A39
MECH#2: length 3.2
  BOTTOM w0.102: UV1.AW1 193.37,104.98 T83.1
MECH#3: length 4
  BOTTOM w0.102: UV1.AW39 165.26,102.59 T84.1
MEM_SMBCLK: length 22.5
  IN3 w0.127: v1(144.74,108.89) 144.71,108.92 144.17,108.92 144.14,108.89 139.43,108.89 138.06,110.25 137.58,110.25 v1(137.38,110.05) 137.38,108.8 v1(137.64,108.53)
  BOTTOM w0.076: UC1.AP2 129.86,106.35 130.16,106.64 130.4,106.64 130.61,106.44 132.64,106.44
  BOTTOM w0.089: 132.64,106.44 132.93,106.44 133.32,106.06 134.77,106.06 v2(136.42,107.7) 137.25,108.53 v1(137.64,108.53)
  BOTTOM w0.102: RP40.1 137.96,112.04 137.89,111.96 137.89,110.5 137.44,110.05 v1(137.38,110.05) ; QC1.6 v1(144.74,108.89)
MEM_SMBDATA: length 22.5
  IN3 w0.127: v1(137.44,110.63) 137.6,110.48 138.16,110.48 139.53,109.12 144.04,109.12 144.24,109.31 145.62,109.31 v1(146.04,108.89)
  BOTTOM w0.076: 134.97,108.81 134.55,109.22 134.55,109.71 134.29,109.97 130.4,109.97 UC1.AH1
  BOTTOM w0.089: v1(137.44,110.63) 137.36,110.63 137,110.27 v2(137,109.57) 137,109.31 136.49,108.81 134.97,108.81
  BOTTOM w0.102: QC1.3 v1(146.04,108.89) ; v1(137.44,110.63) 137.63,110.83 137.63,112.15 138.02,112.54 RP40.2
MIC1-L: length 2.7
  TOP w0.203: CA74.1 27.38,25.92 26.88,25.41 26.88,25.08 26.7,24.9 26.7,24.39 26.88,24.21 UA1.19
MIC_CLK: length 354.2
  TOP w0.102: v1(33.43,19.89) 33.04,19.5 LA1.2 34.31,19.12 CA22.1
  IN1 w0.127: v1(220.93,41.99) 220.48,42.45 220.48,79.81 213.52,86.77 213.52,91.07 216.24,93.8 216.24,97.63 219.12,100.51 219.5,100.51 221.26,102.27 221.26,110.08 219.81,111.53 219.81,116.44 217.5,118.74 217.5,138.76 217.11,139.15 217.11,144.91 217.44,145.24 217.44,161.23 221.34,165.13 221.34,171.89 220.49,172.74 218.92,172.74 v1(218.66,172.48) ; v1(184.05,34.45) 183.25,35.25 180.61,35.25 180.12,34.76 167.41,34.76 160.86,41.31 136.91,41.31 133.25,44.97 105.5,44.97 87.35,26.82 52.36,26.82 46.57,21.03 34.57,21.03 v1(33.43,19.89)
  BOTTOM w0.102: JLVDS.30 218.95,172.77 v1(218.66,172.48) ; v1(220.93,41.99) 220.8,41.87 214.58,41.87 213.85,42.59 202.5,42.59 201.8,41.89 201.27,41.89 200.18,40.8 195.92,40.8 194.39,39.26 194.39,36.91 192.86,35.39 v2(185.97,35.39) 184.99,35.39 v1(184.05,34.45)
MIC_CLK_C: length 2.3
  TOP w0.102: UA1.3 30.58,19.25 30.77,19.05 v2(31.22,19.05) 32.22,19.05 LA1.1
MIC_DATA: length 355.9
  TOP w0.102: v1(38.45,19.37) 37.7,18.62 v2(36.75,18.62) 33.59,18.62 33.48,18.51 31.95,18.51 31.78,18.68 30.79,18.68 30.62,18.85 UA1.2
  IN1 w0.127: v1(38.45,19.37) 39.68,20.6 46.5,20.6 52.46,26.57 87.54,26.57 105.69,44.71 133.15,44.71 136.8,41.06 160.75,41.06 167.31,34.5 180.22,34.5 180.67,34.95 182.98,34.95 183.42,34.51 v1(183.42,34.43) ; v1(221.31,42.56) 220.91,42.97 220.91,79.74 213.77,86.88 213.77,90.8 216.58,93.61 216.58,97.61 219.23,100.26 219.61,100.26 221.52,102.17 221.52,110.18 220.06,111.64 220.06,116.54 217.75,118.85 217.75,138.86 217.36,139.25 217.36,144.81 217.69,145.14 217.69,161.12 221.63,165.06 221.63,172.04 219.61,174.06 v1(219.61,174.51)
  BOTTOM w0.102: v1(221.31,42.56) 214.21,42.56 213.95,42.82 202.4,42.82 201.7,42.12 201.14,42.12 200.04,41.02 195.79,41.02 194.13,39.37 194.13,37.02 192.93,35.82 184.81,35.82 v1(183.42,34.43) ; JLVDS.32 219.95,174.11 219.61,174.44 v1(219.61,174.51)
MIC_IN: length 12.1
  IN1 w1.016: 26.38,24.84 26.05,24.51 24.61,24.51 24.3,24.2 23.37,24.2 22.93,23.76 15.59,23.76
  BOTTOM w0.102: v1(15.84,22.74) 15.84,22.92 v2(16.33,23.41)
  vias: v1(15.26,22.74) v1(27.33,25.09) v1(27.28,24.5)
MIC_IN_R: length 14.9
  TOP w0.102: LA7.1 v2(13.87,20.28)
  IN3 w1.016: 15.46,17.22 15.02,17.22 13.49,18.74 12.67,18.74 12.67,18.74 4.5,18.74 JHP.4
  vias: v1(16.32,17.54) v1(16.32,16.95)
MIIC_SCL: length 6.8
  TOP w0.102: v1(200.52,174.97) 200.72,174.77 200.72,174.61 201.06,174.27 202.05,174.27 202.19,174.13 202.19,174 202.12,173.93 UX4.48
  BOTTOM w0.102: RX169.2 RX171.1 198.96,175.03 199.06,175.13 199.06,175.24 199.16,175.35 200.14,175.35 200.28,175.49 200.66,175.49 200.75,175.4 200.75,175.19 v1(200.52,174.97)
MIIC_SDA: length 7.1
  TOP w0.102: UX4.47 202.52,173.9 202.42,174 202.42,174.22 202.15,174.5 v3(201.57,174.5) 201.15,174.5 200.94,174.7 200.94,174.79 v1(201.12,174.97)
  BOTTOM w0.102: RX168.2 RX170.1 198.96,175.89 199.06,175.79 199.06,175.68 199.16,175.58 200.04,175.58 200.18,175.71 200.76,175.71 200.98,175.49 200.98,175.11 v1(201.12,174.97)
MS_BS: length 16.8
  TOP w0.102: UR1.22 174.52,23.19 173.5,24.22 173.5,24.22 173.4,24.33 172.55,24.33 172.43,24.45 172.43,24.61 172.55,24.73 173.4,24.73 173.5,24.83 173.5,25.04 173.4,25.14 172.55,25.14 172.43,25.26 172.43,25.43 172.55,25.55 v2(172.94,25.55) 173.4,25.55 173.5,25.65 173.5,27.8 176.59,30.9 177.92,30.9 v1(178.21,31.19)
  BOTTOM w0.102: v1(178.21,31.19) 178.56,30.84 JREAD.15
MS_CLK_SD_WP: length 41.4
  TOP w0.102: RR3.2 CR5.1 182.5,21.83 v1(182.59,21.92)
  IN1 w0.127: v1(170.46,28.46) 171.07,29.07 184.19,29.07 v1(186.71,26.55)
  BOTTOM w0.102: JREAD.5 187.68,27.44 186.79,26.55 v1(186.71,26.55) 186.71,22.94 186.58,22.81 182.65,22.81 182.53,22.69 182.53,22.52 182.65,22.4 186.58,22.4 186.71,22.28 186.71,22.04 186.58,21.92 v1(182.59,21.92) ; v1(170.46,28.46) 170.2,28.73 JREAD.22
MS_CLK_SD_WP_R: length 5.1
  TOP w0.102: v2(182.92,20.8) 182.58,20.46 181.36,20.46 RR3.1 179.76,22.06 179.76,22.46 179.53,22.69 UR1.8
MS_D0: length 23.6
  TOP w0.102: UR1.16 176.82,26.64 176.69,26.77 175.87,26.77 175.75,26.89 175.75,27.06 175.87,27.18 176.69,27.18 176.82,27.31 176.82,28.74 177.13,29.06 v2(178.49,29.06) 179.43,29.06 180.39,28.1 v1(180.39,27.72)
  BOTTOM w0.102: JREAD.12 181.6,23.58 181.47,23.45 181.22,23.45 181.09,23.58 181.09,28.78 180.97,28.9 180.52,28.9 180.39,28.78 v1(180.39,27.72)
MS_D1_SD_D3: length 27
  TOP w0.102: v1(179.52,31.19) 179.52,30.93 179.65,30.81 180.24,30.81 180.37,30.68 180.37,30.33 180.24,30.2 v2(179.91,30.2) 176.54,30.2 173.96,27.61 173.96,24.58 174.35,24.19 UR1.20
  BOTTOM w0.102: JREAD.13 180.08,30.59 179.52,31.15 v1(179.52,31.19) 179.91,31.57 189.77,31.57 189.96,31.38 JREAD.3
MS_D2_SD_CLK: length 24.1
  TOP w0.102: v1(178.79,28.59) 178.24,28.03 RR2.2 CR6.1
  IN1 w0.127: v1(183.12,26.81) 183.12,28.2 182.99,28.33 181.98,28.33 181.85,28.2 181.85,25.22 181.73,25.09 181.47,25.09 181.35,25.22 181.35,28.2 181.22,28.33 180.93,28.33 180.81,28.2 180.81,25.22 180.68,25.09 180.32,25.09 180.2,25.21 180.2,27.28 178.9,28.59 v1(178.79,28.59)
  BOTTOM w0.102: v1(178.79,28.59) 179.32,29.11 JREAD.14 ; v1(183.12,26.81) JREAD.10
MS_D2_SD_CLK_R: length 2
  TOP w0.102: UR1.15 177.32,25.88 178.21,26.77 RR2.1
MS_D3: length 24.6
  TOP w0.102: v1(183.96,23.6) 182.87,24.69 v2(181.93,24.69) UR1.12
  BOTTOM w0.102: v1(183.96,23.6) 186.03,23.6 186.16,23.73 186.16,24.48 186.05,24.58 183.9,24.58 183.8,24.68 183.8,24.89 183.9,24.99 186.05,24.99 186.16,25.09 186.16,25.29 186.05,25.4 183.9,25.4 183.8,25.5 183.8,25.7 183.9,25.8 186.05,25.8 186.16,25.9 186.16,27.8 186.05,27.9 185.17,27.9 185.07,28 185.07,28.2 185.17,28.3 186.05,28.3 186.16,28.41 JREAD.7
MS_INS#: length 19.8
  TOP w0.102: UR1.9 181.35,23.19 CR10.1 181.8,23.57 v2(182.7,23.57) 183.29,23.57 v1(183.35,23.63)
  BOTTOM w0.102: JREAD.8 184.64,27.94 184.53,27.84 183.77,27.84 183.67,27.74 183.67,27.54 183.77,27.43 185.65,27.43 185.77,27.32 185.77,27.15 185.65,27.03 183.77,27.03 183.67,26.93 183.67,26.72 183.77,26.62 185.65,26.62 185.77,26.5 185.77,26.33 185.65,26.22 183.48,26.22 183.35,26.09 v1(183.35,23.63)
O-USR: length 5.5
  TOP w0.102: v1(86.01,140.6) 86.01,140.64 85.55,141.09 v2(85.55,142.11)
  TOP w0.254: PR506.2 86.01,140.04 v1(86.01,140.6)
  BOTTOM w0.203: v1(86.01,140.6) 86.19,140.6 86.97,139.81 87.46,139.81 PU501.9
  BOTTOM w0.254: PR502.1 85.94,140.66 v1(86.01,140.6)
OCP_CPU: length 3.7
  TOP w0.102: v2(89.42,141.07) 88.95,140.6 v1(88.61,140.6)
  TOP w0.254: v1(88.61,140.6) 88.48,140.47 PR503.2
  BOTTOM w0.203: PU501.12 89.02,140.19 v1(88.61,140.6)
  BOTTOM w0.254: v1(88.61,140.6) PR501.1
ODD_DA#: length 142.5
  TOP w0.089: RP54.1 131.87,114.13 131.73,113.99 131.73,113.55 v1(131.66,113.48) 131.47,113.29 130.49,113.29 129.91,113.87 128.6,113.87 128.42,114.05 128.42,114.58 128.24,114.77 128.24,115.39 v1(129.32,116.47)
  IN1 w0.127: v1(173.45,93.48) 173.71,93.74 189.3,93.74 190.05,94.49 191.38,94.49 192.91,92.96 196.51,92.96 201.2,97.65 210.24,97.65 210.53,97.36 213.01,97.36 214.17,98.52 215.3,98.52 218.64,101.85 218.64,103.53 220.34,105.23 v1(220.55,105.23)
  IN3 w0.084: v1(131.66,113.48) 131.56,113.48 129.42,111.34 128.88,111.34 128.2,110.67 128.2,109.96 127.92,109.67 126.65,109.67 126.36,109.39 126.36,108.61 126.5,108.47 126.5,107.15 126.81,106.84 137.82,106.84
  IN3 w0.127: 137.82,106.84 138.48,106.84 139.1,107.45 143.59,107.45 144.68,106.37 149.07,106.37 154.14,101.29 161.88,101.29 163.01,100.16 163.01,99.38 170.02,92.37 172.34,92.37 v1(173.45,93.48)
  BOTTOM w0.089: UC1.T3 128.98,116.81 v1(129.32,116.47)
  BOTTOM w0.102: v1(220.55,105.23) 221.44,106.12 222.28,106.12 CS17.1 223.84,105.47 228.06,109.68 228.06,114.04 JODD.11
ODD_DETECT#: length 128.7
  IN1 w0.127: v1(220.55,105.86) 220.48,105.86 218.39,103.77 218.39,101.96 215.2,98.77 214.06,98.77 212.9,97.61 210.64,97.61 210.35,97.9 201.09,97.9 196.41,93.22 193.01,93.22 191.49,94.74 189.94,94.74 189.2,94 175.52,94 175.39,94.13 v1(172.04,94.13)
  IN2 w0.089: v1(137.57,116.32) 137.63,116.32 137.92,116.61
  IN2 w0.127: v1(152.07,105.74) 152.57,106.24 152.57,107.96 152.28,108.25 152.28,109.46 151.92,109.82 151.92,110.64 146.6,115.96 142.4,115.96 141.57,116.79 138.1,116.79 137.92,116.61
  IN3 w0.084: v1(137.57,116.32) 137.42,116.17 136.66,116.17 136.26,116.57 134.24,116.57 133.54,117.27 132.22,117.27 130.77,115.81 128.45,115.81 128,116.26 127.62,116.26 v1(127.26,115.9)
  IN3 w0.127: v1(172.04,94.13) 170.92,94.13 170.38,93.59 169.52,93.59 163.53,99.58 163.53,100.39 162.1,101.82 155.99,101.82 v1(152.07,105.74)
  BOTTOM w0.076: 137.92,115.23 137.57,115.58 v1(137.57,116.32)
  BOTTOM w0.089: UC1.V6 126.99,115.63 v1(127.26,115.9)
  BOTTOM w0.102: 137.92,115.23 137.99,115.16 RP37.1 ; JODD.8 226.05,109.13 224.24,107.31 v2(223.03,107.31) 222.13,106.42 221.1,106.42 v1(220.55,105.86)
ODD_EN: length 8.8
  BOTTOM w0.102: v2(222.96,127.35) 222.96,126.59 RS6.1 ; QS3.1 221.96,126.3 RS6.1 ; RS6.1 222.67,125.13 222.87,124.93 222.87,123.72 CS16.1 222.24,122.27 222.48,122.27 222.85,121.91 QS2.3
ODD_EN#: length 137.8
  TOP w0.102: v1(171.23,92.85) 170.98,92.85 v2(170.73,92.59)
  IN1 w0.084: v1(134.33,114.96) 134.76,115.39 137.32,115.39 137.92,116
  IN1 w0.127: 137.92,116 138.08,116.15 138.33,116.15 139.98,117.8 143.02,117.8 147.13,113.69 147.13,113.13 148.94,111.33 149.5,111.33 152.09,108.73 v1(152.09,107.58) ; v1(216.91,122.03) 216.91,118.91 218.72,117.1 218.72,104.71 217.8,103.79 217.8,102.87 212.8,97.86 210.74,97.86 210.35,98.26 201.09,98.26 196.3,93.47 193.12,93.47 191.56,95.03 189.87,95.03 189.21,94.36 177.52,94.36 176.24,95.64 172.96,95.64 171.23,93.91 v1(171.23,92.85)
  IN3 w0.127: v1(171.23,92.85) 169.9,92.85 163.27,99.48 163.27,100.27 161.99,101.55 155.42,101.55 151.65,105.32 151.65,107.24 151.98,107.58 v1(152.09,107.58)
  BOTTOM w0.089: UC1.Y1 130.46,114.77 131.79,114.77 132.4,115.38 133.9,115.38 v1(134.33,114.96)
  BOTTOM w0.102: QS3.2 221.24,123.32 221.24,122.79 220.87,122.43 219.98,122.43 219.8,122.25 217.13,122.25 v1(216.91,122.03)
ON/OFFBTN#: length 238.7
  TOP w0.102: v1(177.36,45.37) 177.36,44.61 178.65,43.32 179.67,43.32 180.08,42.91 UE1.114 ; v1(168.75,44.38) v4(168.75,42.68) 168.75,41.75 170.48,40.02 174.14,40.02 179.47,34.68 179.47,32.8 181.61,30.67 191.45,30.67 RE49.1 195.55,28.57 CE20.1 195.88,31.13 SW1.3 v1(199.86,31.13) SW1.4 ; v1(43.46,93.99) 43.34,94.11 JPWR.3
  IN3 w0.127: v1(177.36,45.37) 176.6,45.37 176.33,45.11 171.69,45.11 170.97,44.38 v1(168.75,44.38) 168.51,44.61 54.74,44.61 47.72,51.64 47.72,78.56 45.56,80.72 45.56,85.47 43.46,87.56 v1(43.46,93.99)
  BOTTOM w0.102: SW2.3 199.74,39.48 199.74,36.65 199.22,36.13 SW2.4 199.22,31.78 v1(199.86,31.13)
PACIN#: length 3.3
  BOTTOM w0.102: QV14.6 188.48,99.68 188.57,99.77 188.94,99.77 189.13,99.58 QV14.5 189.13,98.44 RV74.2 188.19,98.36 v2(188.14,98.31)
PANEL_BKLEN: length 136.5
  TOP w0.102: v1(193.39,48.71) 193.03,48.71 191.19,50.55 UE1.76
  IN2 w0.127: v1(125.62,129.84) 125.62,129.98 127.93,132.29 136.1,132.29 136.62,131.77 136.62,127.28 143.26,120.64 143.26,118.08 144.37,116.98 148.43,116.98 151.07,114.33 151.07,112.1 152.18,110.99 152.18,109.93 152.53,109.57 152.53,108.39 153.11,107.81 153.11,105.25 157.92,100.44 160.49,100.44 182.32,78.61 182.32,77.78 186.26,73.84 186.26,66.53 185.5,65.76 185.5,54.36 186.24,53.62 v1(186.24,48.47)
  IN3 w0.127: v1(186.24,48.47) 186.6,48.84 189.33,48.84 189.52,48.65 193.32,48.65 193.39,48.71 v1(193.39,48.71)
  BOTTOM w0.076: v1(125.62,129.84) 125.62,126.82 124.83,126.02 UC1.A9
PBTN_OUT#: length 255.9
  TOP w0.102: UE1.106 180.73,46.11 180.37,46.47 178.26,46.47 172.34,52.38 v2(172.34,53.22) 172.34,55.75 v1(172.14,55.95)
  IN1 w0.084: 137.75,107.99 135.59,107.99 135.19,108.39 133.83,108.39 132.85,109.37 129.82,109.37 129.63,109.56 127.7,109.56 127.62,109.64 127.22,109.64 v1(126.82,109.24)
  IN1 w0.127: 137.75,107.99 138.62,108.86 144.17,108.86 144.58,108.44 146.78,108.44 148.15,107.07 148.15,106.55 152.94,101.76 152.94,101.61 160.46,94.08 160.46,91.62 167.02,85.06 171.67,85.06 172.32,84.41 174.36,84.41 178.04,80.73 180.16,80.73 v1(182.89,78)
  IN3 w0.127: v1(65.73,88.7) 66,88.42 66,78.49 70.77,73.72 70.77,72.47 73.14,70.1 73.14,57.34 73.6,56.88 118.11,56.88 119.48,55.52 171.7,55.52 v1(172.14,55.95) 172.95,56.77 174.35,56.77 176.47,58.89 179.14,58.89 185.07,64.82 185.07,65.99 184,67.06 184,69.87 182.89,70.97 v1(182.89,78)
  BOTTOM w0.089: UC1.AL7 126.54,108.96 v1(126.82,109.24)
  BOTTOM w0.102: v1(65.73,88.7) 64.66,88.7 63.67,89.69 RC49.1
PC_BEEP: length 5.6
  TOP w0.102: DA8.1 38.13,23.57 37.99,23.42 v2(37.78,23.42) 36.83,23.42 RA19.1 35.73,24.52 RA79.2
PCH_AUDIO_EN: length 4.7
  BOTTOM w0.076: UC1.P1 131.4,117.59 131.54,117.73 132.92,117.73 RC116.1
  BOTTOM w0.089: RC116.1 133.49,117.88 v2(134.04,117.34)
PCH_AZ_BITCLK: length 7
  BOTTOM w0.076: 125.2,102.25 125.11,102.34 125.11,103.29 UC1.AW8
  BOTTOM w0.089: R2359.2 128.16,98.13 v2(127.43,98.86) 126.24,100.05 126.24,101.2 125.2,102.25
PCH_AZ_CODEC_BITCLK: length 233.8
  TOP w0.102: v1(32.78,19.89) R2355.1 31.52,20.52 31.45,20.45 UA1.6
  IN1 w0.127: v1(131.45,93.19) 144.11,80.53 144.11,70.37 142.78,69.03 142.78,56.61 142.65,56.49 140.31,56.49 140.19,56.36 140.19,53.63 140.06,53.5 139.6,53.5 139.47,53.63 139.47,56.36 139.35,56.49 138.95,56.49 138.83,56.36 138.83,53.12 138.7,52.99 138.28,52.99 138.15,53.12 138.15,56.36 138.03,56.49 137.63,56.49 137.51,56.36 v1(137.51,51.19) ; v1(32.78,19.89) 32.78,20 34.38,21.6 36.81,21.6 36.93,21.73 36.93,22.49 37.06,22.62 37.31,22.62 37.44,22.49 37.44,21.73 37.57,21.6 37.82,21.6 37.95,21.73 37.95,22.49 38.08,22.62 38.33,22.62 38.46,22.49 38.46,21.73 38.58,21.6 38.84,21.6 38.97,21.73 38.97,22.49 39.09,22.62 39.35,22.62 39.47,22.49 39.47,21.73 39.6,21.6 39.85,21.6 39.98,21.73 39.98,22.49 40.11,22.62 40.36,22.62 40.49,22.49 40.49,21.73 40.62,21.6 40.87,21.6 41,21.73 41,22.49 41.12,22.62 41.38,22.62 41.51,22.49 41.51,21.73 41.63,21.6 41.89,21.6 42.01,21.73 42.01,22.49 42.14,22.62 42.39,22.62 42.52,22.49 42.52,21.73 42.65,21.6 42.9,21.6 43.03,21.73 43.03,22.49 43.16,22.62 43.41,22.62 43.54,22.49 43.54,21.73 43.66,21.6 43.92,21.6 44.05,21.73 44.05,22.49 44.17,22.62 44.43,22.62 44.55,22.49 44.55,21.73 44.68,21.6 44.93,21.6 45.06,21.73 45.06,22.49 45.19,22.62 45.44,22.62 45.57,22.49 45.57,21.73 45.7,21.6 46.42,21.6 52.15,27.33 87.1,27.33 89.7,29.93 89.7,30.11 89.42,30.39 89.42,30.57 89.6,30.75 89.78,30.75 90.06,30.47 90.24,30.47 90.42,30.65 90.42,30.83 90.14,31.11 90.14,31.29 90.32,31.47 90.5,31.47 90.78,31.19 90.96,31.19 91.14,31.37 91.14,31.55 90.86,31.83 90.86,32.01 91.04,32.19 91.22,32.19 91.5,31.91 91.68,31.91 91.86,32.09 91.86,32.27 91.58,32.55 91.58,32.73 91.76,32.91 91.94,32.91 92.22,32.63 92.4,32.63 92.58,32.81 92.58,32.99 92.29,33.27 92.29,33.45 92.47,33.63 92.65,33.63 92.94,33.34 93.12,33.34 93.3,33.53 93.3,33.7 93.01,33.99 93.01,34.17 93.19,34.35 93.37,34.35 93.66,34.06 93.84,34.06 94.02,34.24 94.02,34.42 93.73,34.71 93.73,34.89 93.91,35.07 94.09,35.07 94.38,34.78 94.56,34.78 94.74,34.96 94.74,35.14 94.45,35.43 94.45,35.61 94.63,35.79 94.81,35.79 95.09,35.5 95.27,35.5 95.45,35.68 95.45,35.86 95.17,36.15 95.17,36.32 95.35,36.5 95.53,36.5 95.81,36.22 95.99,36.22 96.17,36.4 96.17,36.58 95.89,36.86 95.89,37.04 96.07,37.22 96.25,37.22 96.53,36.94 96.71,36.94 96.89,37.12 96.89,37.3 96.61,37.58 96.61,37.76 96.79,37.94 96.97,37.94 97.25,37.66 97.43,37.66 97.61,37.84 97.61,38.02 97.33,38.3 97.33,38.48 97.51,38.66 97.69,38.66 97.97,38.38 98.15,38.38 98.33,38.56 98.33,38.74 98.05,39.02 98.05,39.2 98.23,39.38 98.4,39.38 98.69,39.1 98.87,39.1 99.08,39.31 99.08,39.49 98.79,39.77 98.79,39.95 98.97,40.13 99.15,40.13 99.44,39.84 99.62,39.84 99.8,40.02 99.8,40.2 99.51,40.49 99.51,40.67 99.69,40.85 99.87,40.85 100.16,40.56 100.34,40.56 100.52,40.74 100.52,40.92 100.23,41.21 100.23,41.39 100.41,41.57 100.59,41.57 100.88,41.28 101.05,41.28 101.24,41.46 101.24,41.64 100.95,41.93 100.95,42.11 101.13,42.29 101.31,42.29 101.59,42 101.77,42 101.95,42.18 101.95,42.36 101.67,42.64 101.67,42.82 101.85,43 102.03,43 102.31,42.72 102.49,42.72 102.67,42.9 102.67,43.08 102.39,43.36 102.39,43.54 102.57,43.72 102.75,43.72 103.03,43.44 103.21,43.44 103.39,43.62 103.39,43.8 103.11,44.08 103.11,44.26 103.29,44.44 103.47,44.44 103.75,44.16 103.93,44.16 104.11,44.34 104.11,44.52 103.83,44.8 103.83,44.98 104.01,45.16 104.19,45.16 104.47,44.88 104.65,44.88 105.25,45.48 137.28,45.48 v1(137.47,45.29)
  BOTTOM w0.089: 130.06,94.58 130.02,94.62 v2(129.63,94.62) 127.85,94.62 CC5.1 128.16,96.21 R2359.1
  BOTTOM w0.102: v1(137.47,45.29) 137.47,51.16 v1(137.51,51.19) ; v1(131.45,93.19) 131.45,93.19 130.06,94.58
PCH_AZ_CODEC_RST#: length 252.5
  TOP w0.102: v1(30.93,22.45) UA1.11
  IN1 w0.084: 130.42,94.94 129.05,96.31 v1(129.05,96.42)
  IN1 w0.127: v1(15.03,25.49) 15.68,24.84 19.47,24.84 21.69,27.06 22.19,27.06 24.29,29.16 30.7,29.16 31.72,28.14 31.72,25.22 30.26,23.76 30.26,22.68 30.48,22.45 v1(30.93,22.45) 30.93,22.55 33.98,25.6 46.83,25.6 51.1,29.87 84.94,29.87 103.72,48.65 111.85,48.65 114.65,51.45 116.55,51.45 117.31,50.68 137.93,50.68 138.05,50.81 138.05,52.35 138.18,52.47 138.55,52.47 138.67,52.35 138.67,50.81 138.8,50.68 139.16,50.68 139.28,50.81 139.28,52.77 139.41,52.89 139.73,52.89 139.86,52.77 139.86,50.81 139.98,50.68 140.59,50.68 140.72,50.81 140.72,55.85 140.85,55.98 141.29,55.98 141.42,55.85 141.42,50.81 141.55,50.68 142.05,50.68 142.18,50.81 142.18,55.83 142.31,55.95 142.85,55.95 142.98,55.83 142.98,53.91 143.11,53.78 143.86,53.78 143.98,53.91 143.98,56.25 144.07,56.33 145.15,56.33 145.28,56.46 145.28,56.71 145.15,56.84 143.54,56.84 143.41,56.97 143.41,57.22 143.54,57.35 145.08,57.35 145.2,57.48 145.2,57.73 145.08,57.86 143.54,57.86 143.41,57.98 143.41,58.24 143.54,58.37 145.15,58.37 145.28,58.49 145.28,58.75 145.15,58.87 143.54,58.87 143.41,59 143.41,59.25 143.54,59.38 145.09,59.38 145.22,59.51 145.22,59.76 145.09,59.89 143.54,59.89 143.41,60.02 143.41,60.27 143.54,60.4 145.15,60.4 145.28,60.52 145.28,60.78 145.15,60.91 143.54,60.91 143.41,61.03 143.41,61.29 143.54,61.41 145.02,61.41 145.15,61.54 145.15,61.79 145.02,61.92 143.54,61.92 143.41,62.05 143.41,62.3 143.54,62.43 145,62.43 145.13,62.56 145.13,62.81 145,62.94 143.54,62.94 143.41,63.06 143.41,63.32 143.54,63.45 144.76,63.45 144.89,63.57 144.89,63.83 144.76,63.95 144.11,63.95 143.98,64.08 143.98,69.42 144.62,70.05 144.62,80.74 130.42,94.94
  BOTTOM w0.089: R2358.1 v1(129.05,96.42)
  BOTTOM w0.102: RA6.1 v1(15.03,25.49)
PCH_AZ_CODEC_SDIN0: length 233.3
  TOP w0.102: RA130.1 33.44,21.85 33.62,21.85 v1(34.32,22.55)
  IN1 w0.084: 131.57,96.78 130.65,96.78 130.1,97.33 127.21,97.33 v1(125.62,98.92)
  IN1 w0.127: v1(34.32,22.55) 35.65,23.89 47.27,23.89 51.73,28.34 85.7,28.34 104.42,47.06 168.75,47.06 171.12,49.44 171.12,61.22 171.69,61.8 171.69,62.18 171.29,62.58 171.29,70.12 169.33,72.08 160.43,72.08 156.4,76.11 152.12,76.11 133.63,94.6 133.63,95.19 133.25,95.58 133.01,95.58 131.81,96.78 131.57,96.78
  BOTTOM w0.089: v1(125.62,98.92) 125.62,99.28 125.89,99.55 125.89,101.06 124.65,102.29 UC1.AY10
PCH_AZ_CODEC_SDOUT: length 230.5
  TOP w0.102: UA1.5 31.08,20.05 31.24,19.89 v1(32.1,19.89)
  IN1 w0.084: v1(126.78,96.4) 127.33,96.96 130.03,96.96 130.71,96.28 130.97,96.28
  IN1 w0.127: v1(32.1,19.89) 32.1,22.11 34.51,24.52 47.19,24.52 51.52,28.85 85.45,28.85 104.17,47.57 167.52,47.57 170.4,50.45 170.4,63.48 170.78,63.87 170.78,69.91 169.14,71.55 159.17,71.55 155.36,75.36 152.15,75.36 132.29,95.22 132.29,95.59 131.6,96.28 130.97,96.28
  BOTTOM w0.089: R2356.1 127.24,96.87 v1(126.78,96.4)
PCH_AZ_CODEC_SYNC: length 223.2
  TOP w0.102: v1(31.53,22.43) 31.08,21.98 30.7,21.98 30.64,22.05 UA1.10
  IN1 w0.084: 131.32,95.84 131.22,95.93 130.43,95.93 v1(129.87,96.49)
  IN1 w0.127: v1(31.53,22.43) 34.19,25.09 47.04,25.09 51.31,29.36 85.2,29.36 103.98,48.14 167.37,48.14 169.89,50.66 169.89,63.04 169.57,63.35 169.57,69.36 167.99,70.94 157.75,70.94 154,74.69 152.11,74.69 131.78,95.01 131.78,95.38 131.32,95.84
  BOTTOM w0.089: R2357.1 130.87,97.48 v1(129.87,96.49)
PCH_AZ_RST#: length 8.6
  BOTTOM w0.076: 125.68,102.54 125.7,102.55 125.7,104.07 125.73,104.11 125.73,104.59 UC1.AU8
  BOTTOM w0.089: R2358.2 128.62,98.38 128.43,98.38 126.75,100.06 v2(126.75,100.49) 126.42,100.81 126.42,101.28 125.68,102.02 125.68,102.54
PCH_AZ_SDOUT: length 10.2
  BOTTOM w0.076: 124.95,102.25 124.95,103.13 124.82,103.26 124.55,103.26 124.3,103.52 124.3,104.34 123.94,104.7 UC1.AU11
  BOTTOM w0.089: RC3.2 RC8.2 R2356.2 127.24,98.2 v2(126.2,99.24) 126.07,99.38 126.07,101.13 124.95,102.25
PCH_AZ_SYNC: length 11.5
  TOP w0.089: v1(128.17,99.27) 128.43,99.53 128.43,101.36 127.76,102.02 125.73,102.02 v2(124.29,103.46) 123.82,103.93 v1(123.53,103.93)
  BOTTOM w0.076: UC1.AV11 123.83,104.23 v1(123.53,103.93)
  BOTTOM w0.089: R2357.2 129.94,97.48 129.48,97.94 129.48,98.35 129.19,98.64 128.81,98.64 v1(128.17,99.27)
PCH_BATLOW#: length 20.5
  TOP w0.089: v1(128.66,107.48) 129.09,107.9 129.57,107.9 130.28,107.19 135.52,107.19 137.57,109.24 137.92,109.24
  TOP w0.102: RC31.2 146.32,109.42 v2(145.54,109.42) 144.3,109.42 144.12,109.24 137.92,109.24
  BOTTOM w0.089: UC1.AN4 128.33,107.14 v1(128.66,107.48)
PCH_DPWROK: length 9.5
  TOP w0.089: RC33.1 RE37.1 128.74,99.08 128.74,100.21 v2(129.09,100.56) v1(129.73,101.2)
  BOTTOM w0.076: UC1.AV5 127.36,103.98 127.36,102.8 127.64,102.52 127.64,102.14 128.2,101.58 129.35,101.58 v1(129.73,101.2)
PCH_GPIO9: length 23.9
  TOP w0.089: v1(129.28,107.48) 129.74,107.01 135.59,107.01 137.53,108.94 137.92,108.94
  TOP w0.102: v1(149.92,107.64) v2(149,107.64) 146.91,107.64 146.37,107.11 146.04,107.11 144.99,108.15 144.68,108.15 143.89,108.94 137.92,108.94
  BOTTOM w0.076: UC1.AM3 128.98,107.78 v1(129.28,107.48)
  BOTTOM w0.102: v1(149.92,107.64) 149.46,108.1 RC125.2
PCH_GPIO12: length 2.1
  TOP w0.089: v1(126.97,108.4) 126.84,108.4 126.18,109.07 T182.1
  BOTTOM w0.089: v1(126.97,108.4) 126.7,108.13 UC1.AM7
PCH_GPIO14: length 2.6
  TOP w0.089: v1(127.83,110.17) 128.08,109.92 129.16,109.92 T126.1
  BOTTOM w0.076: UC1.AH4 127.95,110.06 v1(127.83,110.17)
PCH_GPIO25: length 1.1
  TOP w0.089: T127.1 128.36,107.77 v1(128.04,107.45)
  BOTTOM w0.089: v1(128.04,107.45) 128.33,107.74 UC1.AM4
PCH_GPIO35: length 9.7
  IN3 w0.127: v1(138.29,115.66) 138.08,115.45 133.44,115.45 132.23,116.66 v1(132.23,116.75)
  BOTTOM w0.076: v1(132.23,116.75) 132.23,116.67 131.66,116.09 UC1.U1
  BOTTOM w0.102: RP37.2 v1(138.29,115.66)
PCH_GPIO37: length 13
  BOTTOM w0.076: UC1.AC1 130.75,113.1 131.51,113.85 132.77,113.85 133.26,113.37 135.25,113.37 135.45,113.17 136.81,113.17 137.32,113.68 137.32,115.07
  BOTTOM w0.089: 137.32,115.07 137.32,115.26 137,115.58 v2(137,115.83) 137,116.33 137.39,116.72 137.92,116.72
  BOTTOM w0.102: 137.92,116.72 138.12,116.72 138.68,116.16 RP37.3
PCH_GPIO44: length 15.8
  TOP w0.089: 137.92,109.67 137.8,109.55 137,109.55 136.3,108.85 v2(135.37,108.85) 134.97,108.85 134.59,109.23 v1(134.13,109.23)
  TOP w0.102: 137.92,109.67 137.99,109.74 142.35,109.74 v1(142.4,109.69)
  BOTTOM w0.076: v1(134.13,109.23) 133.55,109.81 130.09,109.81 129.92,109.64 129.14,109.64 129.1,109.68 128.62,109.68 UC1.AK4
  BOTTOM w0.102: v1(142.4,109.69) 142.15,109.94 RC104.1
PCH_GPIO46: length 27.3
  IN3 w0.084: v1(129.32,110.47) 131.42,112.57 134.33,112.57 135.63,111.27 137.82,111.27
  IN3 w0.127: 137.82,111.27 138.95,111.27 139.84,110.38 143.15,110.38 143.83,109.7 149.39,109.7 149.4,109.7 149.75,109.7 149.75,109.7 150.06,109.7 v1(150.78,108.98)
  BOTTOM w0.076: UC1.AG3 128.98,110.82 v1(129.32,110.47)
  BOTTOM w0.102: RC124.2 150.35,107.21 150.62,107.49 v2(150.62,108.12) 150.62,108.82 v1(150.78,108.98)
PCH_GPIO47: length 1.2
  TOP w0.089: v1(126.62,113.07) 126.62,113.31 T174.1
  BOTTOM w0.089: v1(126.62,113.07) 126.99,113.45 UC1.AB6
PCH_GPIO48: length 3.2
  TOP w0.089: v1(127.95,117.9) 128.17,117.9 128.54,117.52 T124.1
  BOTTOM w0.076: UC1.U4 128.33,116.08 128.02,116.39 128.02,117.82 v1(127.95,117.9)
PCH_GPIO49: length 4.6
  BOTTOM w0.076: 133.33,114.33 133.3,114.3 129.23,114.3 UC1.Y3
  BOTTOM w0.089: T125.1 133.33,114.33
PCH_GPIO66: length 9.1
  BOTTOM w0.076: 131.6,124.03 130.14,124.03 129.93,123.83 129.93,123.38 129.75,123.19 129.31,123.19 UC1.D3
  BOTTOM w0.089: v2(135.22,126.89) 135.34,126.77 RC118.2 135.04,125.58 RC122.1 134.41,125.31 133.63,124.53 132.11,124.53 131.6,124.03
PCH_GPIO83: length 2.1
  TOP w0.089: v1(126.51,116.82) 127.02,117.33 127.58,117.33 T177.1
  BOTTOM w0.089: v1(126.51,116.82) 126.99,117.31 UC1.R6
PCH_GPIO84: length 1.6
  TOP w0.089: T176.1 126.28,119.25 126.65,118.88 v1(126.65,118.76)
  BOTTOM w0.089: v1(126.65,118.76) 126.99,119.1 UC1.L6
PCH_GPIO85: length 1.5
  TOP w0.089: v1(127.35,117.74) 126.94,118.15 T175.1
  BOTTOM w0.089: v1(127.35,117.74) 126.99,118.09 UC1.N6
PCH_GPIO89: length 2.1
  TOP w0.089: T178.1 125.36,118.25 126.14,118.25 v1(126.58,117.8)
  BOTTOM w0.089: v1(126.58,117.8) 126.34,118.05 UC1.N7
PCH_GPIO90: length 3
  BOTTOM w0.089: UC1.K2 130.01,119.45 130.94,119.45 131.82,120.33 T179.1
PCH_GPIO93: length 3.3
  BOTTOM w0.076: UC1.J2 129.92,120.88 130.47,120.88 130.74,121.15 130.74,121.32 130.83,121.41 131.16,121.41
  BOTTOM w0.089: T180.1 131.33,121.57 131.16,121.41
PCH_GPIO94: length 4.4
  BOTTOM w0.089: UC1.G1 130.69,121.75 130.88,121.75 131.19,122.06 134.39,122.06 T181.1
PCH_HOT#: length 108.6
  TOP w0.089: v1(135.76,102.15) 135.76,102.09 135.96,101.89 135.96,101.45 135.96,101.44
  TOP w0.102: v1(191.41,54.92) 191.41,55.09 RE7.1 ; 135.96,101.44 135.96,101.4 138.62,98.74 139.05,98.74 139.27,98.52 139.69,98.1 139.71,98.08 v2(144.25,98.08) 152.72,98.08 157.26,93.55 163.74,93.55 168.1,89.19 168.1,85.26 174.84,78.51 174.84,71.81 175.29,71.37 175.29,57.36 176.4,56.25 176.4,52.24 v1(177.51,51.13)
  IN3 w0.127: v1(177.51,51.13) 177.59,51.05 190.65,51.05 191.41,51.81 v1(191.41,54.92)
  BOTTOM w0.076: 131.57,102.53 129.54,102.53 129.34,102.73 129.34,103.07 129.29,103.12 129.29,103.73 129.06,103.96 128.84,103.96 128.66,104.13 128.66,104.35 128.3,104.72 UC1.AU4
  BOTTOM w0.089: 135.02,102.47 R2330.2 135.54,102.49 135.55,102.49 135.73,102.31 135.73,102.18 v1(135.76,102.15)
  BOTTOM w0.102: 131.57,102.53 132.12,101.98 134.52,101.98 135.02,102.47
PCH_INTVRMEN: length 12.6
  BOTTOM w0.076: UC1.AV7 125.86,103.98 125.86,102.34
  BOTTOM w0.089: 131.57,96.85 131.35,97.08 131.35,97.8 v2(130.51,98.64) 129.46,98.64 128.33,99.77 127.96,99.77 126.6,101.13 126.6,101.35 125.86,102.09 125.86,102.34
  BOTTOM w0.102: 131.57,96.85 132.03,96.39 RC1.2 133.04,96.39 RC2.1
PCH_JTAG_JTAGX: length 9.7
  BOTTOM w0.076: UC1.AE63 90.27,111.64
  BOTTOM w0.102: 84.62,110.69 RC59.1 ; 84.62,110.69 RC62.2 84.62,112.27 v2(84.19,112.7) ; 84.62,110.69 84.64,110.68 RC130.1 86.07,110.68 86.14,110.61 89.25,110.61 90.27,111.64
PCH_JTAG_RST#: length 68.2
  TOP w0.102: RC57.2 R2341.2 73.55,113.23 72.95,113.23 72.71,112.99 72.71,110.79 73.77,109.73 75.17,109.73 75.89,109 75.89,105.71 75.49,105.31 75.49,101.06 73.37,98.94 73.37,93.1 v4(69.85,89.58) v1(67.34,89.58)
  BOTTOM w0.076: 90.64,104.7 91.16,105.22 91.79,105.22 92.11,104.9 UC1.AU62
  BOTTOM w0.089: 87.92,101.98 87.12,101.18
  BOTTOM w0.102: 90.64,104.7 87.92,101.98 ; v1(67.34,89.58) 74.5,89.58 74.95,90.03 74.95,95.26 77.9,98.21 84.15,98.21 87.12,101.18
PCH_JTAG_TCK: length 58.6
  TOP w0.102: v1(66.62,88.89) v4(66.62,88.27)
  IN3 w0.127: v1(66.62,88.89) 66.79,88.71 70.25,88.71 71.53,89.99 71.53,98.37 75.15,101.99 75.15,106.06 v1(76.74,107.64)
  BOTTOM w0.076: 90.39,111.45 91.35,111.45 91.46,111.34 91.71,111.34 91.82,111.39 91.87,111.42 92.08,111.42 UC1.AE62
  BOTTOM w0.102: v1(76.74,107.64) 77.25,108.15 78.42,108.15 79.18,108.91 82.33,108.91 83.02,108.21 83.93,108.21 RC135.1 RC65.2 84.81,109.99 87.71,109.99 88.15,110.42 89.36,110.42 90.39,111.45 ; RP46.4 59.1,86.36 60.54,84.91 64.74,84.91 66.78,86.95 66.78,88.73 v1(66.62,88.89)
PCH_JTAG_TDI: length 26.9
  TOP w0.089: 88.45,111.3 88.64,111.3 v1(88.68,111.26) 89.06,110.88 90.14,110.88 90.83,111.58 92.87,111.58 93.3,112.01 v1(93.3,112.03)
  TOP w0.102: v1(80.31,110.56) 82.53,112.79 86.96,112.79 v4(87.36,112.38) 88.45,111.3
  BOTTOM w0.089: v1(88.68,111.26) 88.4,110.99 RP48.8 ; UC1.AD61 92.95,112.38 v1(93.3,112.03)
  BOTTOM w0.102: v1(80.31,110.56) 79.68,109.94 79.52,109.94 78.22,108.63 76.15,108.63 75.75,108.23 75.75,105.77 75.49,105.51 75.49,104.49 75.21,104.21 RC44.1
PCH_JTAG_TDO: length 25.9
  TOP w0.089: v1(89.31,111.26) 89.31,111.57 88.91,111.96
  TOP w0.102: 88.91,111.96 RC63.2 87.77,113.1 82.24,113.1 v4(81.23,112.09) v1(79.72,110.59) ; v1(89.31,111.26) 90.07,111.26 90.82,112.01 v1(92.65,112.01)
  BOTTOM w0.089: v1(92.65,112.01) 92.95,111.71 UC1.AE61 ; 88.91,111.66 v1(89.31,111.26)
  BOTTOM w0.102: 88.91,111.66 88.87,111.71 88.48,111.71 88.27,111.49 RP48.7 ; RC43.1 74.98,106.95 74.98,109.43 75.45,109.9 75.45,110.18 75.86,110.59 v1(79.72,110.59)
PCH_JTAG_TMS: length 36.8
  TOP w0.102: v1(76.32,113.04) v4(76.99,113.04)
  BOTTOM w0.089: UC1.AD62 91.9,111.99 88.91,111.99
  BOTTOM w0.102: 88.74,111.99 88.74,112.54 88.48,112.79 86.13,112.79 85.88,113.04 v1(76.32,113.04) 72.36,113.04 69.94,110.63 65.59,110.63 65.15,110.19 65.15,106.2 65.94,105.42 RC46.1 ; 88.74,111.99 88.91,111.99 ; 88.74,111.99 RP48.6
PCH_OPI_COMP: length 7.7
  BOTTOM w0.076: UC1.AW15 121.95,103.29 121.95,101.66 122.71,100.9
  BOTTOM w0.305: RC101.1 124.28,97.24 122.77,98.76 122.77,99.34 v2(122.93,99.51) 122.93,100.25 122.77,100.41 122.77,100.85 122.71,100.9
PCH_PCIE_RCOMP: length 5.2
  BOTTOM w0.089: RC91.2 114.66,130.38 v2(114.59,130.45)
  BOTTOM w0.305: RC91.2 114.66,128.94 114.9,128.7 114.9,126.49 114.59,126.19 114.59,125.72 UC1.A27
PCH_PLTRST#: length 31.8
  TOP w0.089: 137.92,107.93 136.74,106.75 v4(136.28,106.75) 129.75,106.75 129.42,107.08 127.89,107.08 127.47,107.5 127.47,108.63 127.23,108.86 126.67,108.86 126.45,109.08 126.45,109.4 126.71,109.66 v1(126.71,110.18)
  TOP w0.102: 148.25,107.13 148.25,106.44 ; 148.25,107.13 148.02,107.36 146.95,107.36 146.47,106.88 145.94,106.88 144.9,107.92 144.59,107.92 143.79,108.72 138.71,108.72 137.92,107.93 ; 148.25,107.13 150.05,107.13 150.26,107.34 CC33.1 ; 148.25,106.44 UC3.1 ; 148.25,106.44 147.74,106.44 147.6,106.3 UC3.2
  BOTTOM w0.076: UC1.AG7 126.71,110.28 v1(126.71,110.18)
PCH_PWR_EN: length 70.5
  TOP w0.102: v1(162.46,36.71) 163.35,37.6 163.35,52.91 163.99,53.54 v2(167.12,53.54) 170.86,53.54 175.8,48.6 175.8,47.19 176.77,46.21 178.22,46.21 RE36.1
  IN1 w0.127: v1(142.33,31.63) 147.41,36.71 v1(162.46,36.71)
  BOTTOM w0.102: R416.1 143.04,25.33 142.33,26.05 v1(142.33,31.63)
PCH_PWROK: length 137
  TOP w0.089: v1(132.81,112.02) 132.81,112.21 132.68,112.34 RP50.3 ; v1(132.81,112.02) 132.81,111.96 132.68,111.84 RP50.2 ; v1(132.81,112.02) 133.44,112.66 CC34.1
  TOP w0.102: UE1.32 195.59,34.66 v1(195.8,34.45) 195.93,34.32 RE18.1 197.11,33.8 ; 197.11,33.8 v4(198.1,33.8) ; 197.11,33.8 CE31.1
  IN1 w0.084: 137.72,111.52 137.06,111.52 136.06,110.52 134.66,110.52 134.44,110.29 130.81,110.29 130.33,110.78 130.33,111.77 130.58,112.02 v1(132.81,112.02)
  IN1 w0.127: 137.72,111.52 141.8,111.52 143.48,113.19 144.26,113.19 144.37,113.3 144.8,113.3 145.9,112.2 145.9,111.92 146.4,111.43 146.94,111.43 148.87,109.5 150.88,109.5 151.63,108.75 151.63,105.59 151.95,105.27 152.76,105.27 153.95,104.07 153.95,102.25 165.01,91.19 165.01,88.5 167.43,86.09 174.12,86.09 178.46,81.75 182.49,81.75 188.79,75.45 188.79,65.41 189.83,64.37 189.83,57.33 190.73,56.43 190.73,54.64 191.47,53.9 191.47,50.64 191.91,50.2 191.91,47.76 191.58,47.42 191.58,44.68 v1(191.75,44.51)
  IN3 w0.127: v1(191.75,44.51) 192.8,43.46 194.77,43.46 196.85,41.38 196.85,36.37 195.8,35.32 v1(195.8,34.45)
PCH_PWROK_R: length 17.6
  TOP w0.089: v2(126.68,101.71) 127,101.39 v1(127,101.35) ; v1(127.85,111.14) 129.17,111.14 129.87,111.84 RP50.7
  IN3 w0.084: v1(127,101.35) 126.15,102.2 126.15,108.33 126.01,108.47 126.01,109.72 126.15,109.87 126.15,110.65 126.27,110.76 127.48,110.76 v1(127.85,111.14)
  BOTTOM w0.089: v1(127,101.35) 127,101.35 126.89,101.35 126.15,102.08 UC1.AY7
PCH_RSMRST#_R: length 8.6
  TOP w0.089: v1(127.74,101.17) v2(126.62,100.04) 126.06,99.49 RC33.2 126.06,98.08 RC41.2
  BOTTOM w0.076: v1(127.74,101.17) 127.74,101.53 127.35,101.93 126.88,101.93 126.87,101.93 126.78,101.93 126.61,102.1 126.61,103.29 126.84,103.52 UC1.AW6
PCH_RTCRST#: length 157.5
  TOP w0.089: 131.57,96.25 131.23,96.6 131.23,97.6 130.84,97.99 130.84,100.94 127.2,104.58 v1(126.53,104.58)
  TOP w0.102: 131.57,96.25 RC6.2 132.31,95.51 CC4.2 133.05,94.45 133.71,93.79 152.26,93.79 155.08,90.97 162.7,90.97 163.34,91.6 164.53,91.6 166.78,89.35 166.78,85.43 174.02,78.19 v4(174.02,74.74) 174.02,71.37 174.58,70.81 174.58,58.49 v1(174.08,58)
  BOTTOM w0.076: UC1.AU7 126.23,104.88 v1(126.53,104.58)
  BOTTOM w0.102: CMOS1.2 113.66,47.52 114.71,48.57 126.92,48.57 131.5,53.15 161.41,53.15 166.24,57.99 174.08,57.99 v1(174.08,58)
PCH_RTCX1: length 26.4
  BOTTOM w0.076: 128.02,102.36 128.02,103.21 UC1.AW5
  BOTTOM w0.102: RG3.2 146.86,102.3 YC1.1 147.3,100.72 147.65,100.37 147.65,99.82 146.97,99.13 CC1.2 146.03,98.24 RC4.1 v2(143.55,98.24) 139.43,98.24 136.51,101.16 130.61,101.16 129.79,101.98 128.4,101.98 128.02,102.36
PCH_RTCX1_R: length 192.5
  TOP w0.102: v1(75.85,46.47) 75.85,43.89 75.59,43.63 v2(75.34,43.63) 73.18,43.63 73.03,43.49 UG1.9
  IN1 w0.127: v1(76.11,54.98) 75.26,54.13 75.26,47.05 v1(75.85,46.47)
  IN3 w0.127: v1(147.79,103.22) 148.86,102.16 150.35,102.16 151.91,100.59 160.9,100.59 184.42,77.08 184.42,71.44 186.64,69.21 186.64,65.33 179.57,58.25 176.73,58.25 174.55,56.07 173.84,56.07 172.63,54.85 118.96,54.85 117.57,56.25 82.67,56.25 81.4,54.98 v1(76.11,54.98)
  BOTTOM w0.102: RG3.1 v1(147.79,103.22)
PCH_RTCX2: length 25.4
  BOTTOM w0.102: UC1.AY5 127.83,102.79 127.83,102.28 128.32,101.79 129.71,101.79 130.82,100.67 136.17,100.67 139.09,97.75 v2(141.4,97.75) 146.42,97.75 RC4.2 147.78,99.11 CC2.2 149.36,100.71 YC1.2
PCH_SMB_ALERT#: length 21
  IN3 w0.084: v1(134.01,107.83) 134.4,107.45 135.47,107.45 135.54,107.52 137.92,107.52
  IN3 w0.127: v1(145.17,107.08) 145.17,107.08 144.29,107.96 138.84,107.96 138.4,107.52 137.92,107.52
  BOTTOM w0.076: v1(134.01,107.83) 133.51,107.33 130.97,107.33 130.85,107.45 130.58,107.45 130.47,107.56 130.08,107.56 UC1.AN2
  BOTTOM w0.102: R2329.2 143.19,109.06 v2(143.46,108.79) 145.17,107.08 v1(145.17,107.08)
PCH_SPI_CLK: length 14
  IN1 w0.084: v1(129.28,113.47) 130.04,113.47 131,114.43 137.73,114.43 137.92,114.62
  IN1 w0.127: 137.92,114.62 139.36,116.06 v1(140.94,116.06)
  BOTTOM w0.076: v1(129.28,113.47) 128.98,113.77 UC1.AA3
  BOTTOM w0.102: R2333.2 141.48,115.86 141.28,116.06 v1(140.94,116.06)
PCH_SPI_CLK_R: length 44.3
  IN3 w0.127: v1(151.4,117.45) 150.98,117.02 145.12,117.02 144.99,116.89 144.06,116.89 143.66,116.49 v1(143.35,116.49)
  BOTTOM w0.102: 142.55,115.85 C2326.1 ; 142.55,115.85 142.71,115.85 v1(143.35,116.49) ; 142.55,115.85 R2333.1 ; U2302.6 158.67,88.04 159.33,88.69 159.33,90.97 156.3,93.99 156.3,104.75 155.3,105.75 155.3,109.45 154.47,110.28 154.47,110.88 154.14,111.21 v2(154.14,112.79) 154.14,114.71 v1(151.4,117.45)
PCH_SPI_CS0#: length 68
  IN3 w0.084: v1(126.52,114.94) 126.07,115.39 125.63,115.39 125.51,115.52 125.51,116.02 125.76,116.28 126.77,116.28 127.02,116.53 127.39,116.53 128.17,117.3 130.15,117.3 130.78,117.93 133.68,117.93 134.31,117.29 136.17,117.29 137.54,118.67 137.72,118.67
  IN3 w0.127: 137.72,118.67 139.7,118.67 140.01,118.97 142.94,118.97 143.35,119.38 147.42,119.38 147.72,119.09 149.18,119.09 v1(149.28,119.18)
  BOTTOM w0.076: v1(126.52,114.94) 126.34,114.76 UC1.Y7
  BOTTOM w0.102: v1(149.28,119.18) 149.28,116.84 152.12,114 152.12,108.46 152.54,108.04 152.54,107.78 153.12,107.2 153.12,97.28 147.6,91.77 v2(147.6,87.41) 147.6,86.69 148.79,85.5 U2302.1
PCH_SPI_HOLD1#: length 48.9
  IN3 w0.127: v1(141.51,118.46) 141.51,118.31 142.3,117.52 143.23,117.52 143.63,117.92 144.56,117.92 144.7,118.06 149.74,118.06 150.26,118.58 150.86,118.58 v1(151.4,118.04)
  BOTTOM w0.102: v1(141.51,118.46) 141.01,117.96 RP39.4 ; v1(151.4,118.04) 151.5,118.04 154.63,114.91 154.63,111.41 154.96,111.08 154.96,110.48 155.78,109.65 155.78,105.95 156.78,104.95 v2(156.78,97.59) 156.78,94.19 159.81,91.17 159.81,87.78 158.79,86.77 U2302.7
PCH_SPI_HOLD#: length 18.3
  IN1 w0.127: v1(140.94,117.29) 141.57,116.66 141.57,115.83 141.18,115.44 139.46,115.44 138.09,114.07 136.44,114.07 136.05,113.68 136.05,112.85 v1(135.98,112.79)
  BOTTOM w0.076: v1(135.98,112.79) 134.84,111.64 v2(134.43,111.64) 130.32,111.64 UC1.AF1
  BOTTOM w0.102: R2335.2 141.3,117.29 v1(140.94,117.29) 140.86,117.29 140.68,117.48 139.92,117.48 139.44,117.96 RP39.5
PCH_SPI_MISO: length 14.1
  IN1 w0.084: v1(137.76,117.87) 136.43,117.87 133.94,115.38 131.66,115.38 130.26,113.98 v1(127.82,113.98)
  BOTTOM w0.089: 137.92,118.54 137.76,118.37 v1(137.76,117.87) ; UC1.AA4 127.92,113.88 v1(127.82,113.98)
  BOTTOM w0.102: RP39.7 138.46,118.96 138.38,118.88 138.27,118.88 137.92,118.54
PCH_SPI_MISO_1: length 48.4
  IN3 w0.127: v1(142.14,118.46) 142.57,118.03 143.02,118.03 143.86,118.88 147.12,118.88 147.43,118.57 149.53,118.57 v1(149.76,118.8)
  BOTTOM w0.102: v1(149.76,118.8) 149.76,117.04 152.7,114.11 152.7,108.67 153.03,108.33 153.03,107.98 153.6,107.4 153.6,96.95 148.17,91.53 v2(148.17,90.43) 148.17,87.51 148.92,86.77 U2302.2 ; v1(142.14,118.46) 141.64,118.96 RP39.2
PCH_SPI_MOSI: length 13.8
  IN1 w0.084: v1(133.75,115.01) 133.85,115.01 136.2,117.36 137.92,117.36
  IN1 w0.127: v1(138.21,119.39) 138.84,118.76 138.84,118.04 138.16,117.36 137.92,117.36
  BOTTOM w0.076: v1(133.75,115.01) 133.75,114.23 133.65,114.14 130.16,114.14 129.86,113.84 UC1.AA2
  BOTTOM w0.102: v1(138.21,119.39) 138.27,119.46 RP39.8
PCH_SPI_MOSI_1: length 45.8
  IN3 w0.127: v1(148.87,119.66) 148.81,119.6 147.93,119.6 147.64,119.89 143.13,119.89 142.76,119.52 141.18,119.52 v1(140.87,119.83)
  BOTTOM w0.102: v1(148.87,119.66) 150,119.66 150.91,118.76 150.91,117.26 153.66,114.51 153.66,111.01 153.99,110.68 153.99,110.08 154.82,109.25 154.82,106.51 154.56,106.26 154.56,95.05 158.84,90.77 158.84,89.48 158.67,89.31 U2302.5 ; RP39.1 140.69,119.46 140.87,119.64 v1(140.87,119.83)
PCH_SPI_WP1#: length 46.7
  IN3 w0.127: v1(150.43,118.03) 149.94,117.54 144.91,117.54 144.78,117.41 143.85,117.41 143.44,117 141.99,117 140.87,118.12 v1(140.87,118.46)
  BOTTOM w0.102: v1(150.43,118.03) 150.4,118 150.4,117.09 153.18,114.31 153.18,110.81 153.51,110.48 153.51,108.18 154.08,107.6 154.08,96.63 148.75,91.29 148.75,88.59 149.3,88.04 U2302.3 ; RP39.3 v1(140.87,118.46)
PCH_SPI_WP#: length 18.6
  IN1 w0.084: 137.92,118.25 136.51,118.25 133.97,115.71 131.41,115.71 130.14,114.44 127.67,114.44 v1(127.17,114.94)
  IN1 w0.127: 137.92,118.25 v1(138.33,118.25)
  BOTTOM w0.076: UC1.Y6 126.99,114.76 v1(127.17,114.94)
  BOTTOM w0.102: RP39.6 138.67,118.46 138.46,118.25 v1(138.33,118.25) 138.33,117.55 138.91,116.97 140.45,116.97 140.67,116.75 R2334.2
PCH_X1_R: length 256.1
  TOP w0.089: 118.83,131.11 118.83,130.56 117.57,129.3 117.57,128.2 116.08,126.72 116.08,123.45 116.34,123.2 116.34,120.58 116.08,120.33 116.08,119.56 115.29,118.76 115.29,113.37 116.13,112.52 116.13,110.56 116.79,109.9 116.79,94.47 117.33,93.94
  TOP w0.102: 118.83,131.11 118.83,132.17 119.82,133.16 119.82,135.98 RG6.1 ; 117.33,93.94 v2(121.14,90.13) 121.83,89.43 149.74,89.43 150.96,88.21 162.13,88.21 171.9,78.45 171.9,64.58 173.28,63.19 173.28,59.17 172.98,58.86 172.98,57.49 175.48,54.99 175.48,51.64 v1(174.77,50.92) ; UG1.5 72.23,40.11 72.36,39.99 72.36,37.73 v1(72.04,37.41)
  IN1 w0.127: v1(175.53,40.21) 175.15,40.59 175.15,48.25 174.77,48.63 v1(174.77,50.92)
  IN3 w0.127: v1(175.53,40.21) 174.69,41.04 94.14,41.04 91.23,38.14 72.76,38.14 v1(72.04,37.41)
PCIE_B+: length 1.3
  BOTTOM w0.102: PC1301.1 196.12,60.72 v2(196.24,60.84)
PCIE_CRX_C_GTX_N0: length 11.8
  TOP w0.102: CV44.2 160.33,117.05 v3(162.8,117.05) 163.47,117.05 163.99,116.53 166.22,116.53 166.75,117.07 167.74,117.07 168.7,118.02 169.13,118.02
  TOP w0.109: v1(169.64,118.72) 169.57,118.72 169.44,118.59 169.44,118.34 169.13,118.02
  BOTTOM w0.102: UV1.Y32 169.26,118.99 169.54,118.72 v1(169.64,118.72)
