# Allegro board LAA491PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18009245: length 5
  TOP w0.254: PC717.2 166.83,166.49 v1(166.98,166.63) 166.99,166.64 PU701.1
  BOTTOM w0.102: PR704.1 166.05,165.95 v2(165.65,165.55)
  BOTTOM w0.254: PC708.1 166.4,167.21 v1(166.98,166.63) 166.78,166.44 PR704.1
N18009258: length 32.2
  TOP w0.254: v1(144.11,179.14) 144.05,179.08 144.05,178.89 144.68,178.25 149.83,178.25 v2(150.13,178.56) 151.87,180.3 158.4,180.3 158.93,179.96 159.65,179.5 159.65,179.5 160.7,178.84 160.84,178.75 160.84,178.75 161.05,178.62 161.13,178.64 161.54,178.48 163.29,176.73 163.48,176.54 168.14,176.54 168.62,176.06 168.62,175.17 PC722.2 168.56,175.05 PR710.2 169.52,173.95 PC719.1
  BOTTOM w0.254: PR716.3 143.73,179.52 v1(144.11,179.14)
N18009264: length 0.7
  TOP w0.102: v1(145.37,162.42) 145.37,162 v2(145.19,161.82)
N18009271: length 5
  TOP w0.254: PC717.1 167.75,166.45 v1(167.56,166.63) 167.49,166.71 PU701.2
  BOTTOM w0.102: v2(168.73,165.42) 168.21,165.95 PR717.1
  BOTTOM w0.254: PR717.1 167.67,166.52 v1(167.56,166.63) 167.56,167.5 PC707.1
N18009295: length 31.2
  TOP w0.254: PR708.2 167.67,175.08 PC722.1 168.24,175.65 168.24,175.9 167.98,176.16 163.32,176.16 162.83,176.65 161.33,178.15 161.1,178.24 160.98,178.21 160.79,178.33 160.73,178.36 160.69,178.36 160.6,178.45 160.34,178.61 159.43,179.19 158.29,179.92 152.7,179.92 v2(152.24,179.46) 150.65,177.87 144.52,177.87 143.67,178.73 143.67,178.89 v1(143.48,179.08)
  BOTTOM w0.254: v1(143.48,179.08) 143.48,179.02 143.73,178.76 PR716.2
N18009369: length 2
  TOP w0.254: PU701.9 170.5,169.93 171.34,170.76 PR714.2
N18009411: length 1.4
  BOTTOM w0.102: PR706.1 148.24,183.91 v2(148.58,184.24)
N18009417: length 2
  TOP w0.102: 156.37,176.6 PR722.1 v2(156.37,178.64)
N18009452: length 3.6
  TOP w0.102: PQ708.2 172.81,175.01 v2(173.37,174.45)
  TOP w0.254: PC723.1 PR724.2 172.13,176.09 PQ708.2
N18009461: length 1.8
  TOP w0.254: PR715.2 171.16,169.87 170.72,169.43 PU701.8
N18107051: length 4.2
  BOTTOM w0.102: UV1.AM39 164.47,109.69 v2(163.41,108.62) 162.61,107.83 RV127.1
N18262754: length 4.7
  TOP w0.102: v1(168.17,115.15) 168.17,114.04 v2(167.79,113.65) RV207.1
  BOTTOM w0.102: v1(168.17,115.15) 168.17,114.78 UV1.AF33
N18284053: length 0.7
  TOP w0.102: v1(134.99,175.22) v2(135.65,175.22)
N18386761: length 5
  TOP w0.102: UV3.J13 189.62,142.76 189.62,140.77 v2(190.21,140.18) RV31.2
N18923200: length 2.3
  TOP w0.102: v2(203.39,10.6) 203.56,10.42 v1(204.05,10.42)
  BOTTOM w0.508: DC1.2 203.96,10.52 v1(204.05,10.42) RC10.1
N19505504: length 1.6
  TOP w0.089: v1(128.63,111.97) 128.05,112.55 T117.1
  BOTTOM w0.076: UC1.AD4 128.33,112.27 v1(128.63,111.97)
N19636367: length 6
  BOTTOM w0.254: QA6.2 14.76,21.35 14.38,21.73 14.38,23.18 v2(14.76,23.55) RA6.2 RA7.2
N19794620: length 6.1
  BOTTOM w0.254: 18.76,21.35 18.81,21.4 18.81,23.01 v2(18.45,23.37) 17.62,24.2 RA5.2 ; 18.76,21.35 QA6.5 ; 18.76,21.35 18.76,20.9 18.56,20.7 QA6.6
N21178712: length 1.7
  TOP w0.102: v2(132.91,172.71) 132.7,172.92 PR5.2
N21178859: length 4.5
  TOP w0.254: PC1302.1 194.67,61.62 194.89,61.4 v2(195.58,61.4) v1(196.3,61.4)
  BOTTOM w0.254: v1(196.3,61.4) 195.81,61.4 195.16,62.06 PU1300.7
N21219517: length 17.3
  TOP w0.102: RV64.2 v4(179.24,104.46) v1(180.31,103.39)
  IN3 w0.102: 180.01,103.69 179.93,103.77 179.93,104.38 179.71,104.59 179.71,110.12 179.22,110.62 179.22,112.21 180.14,113.13 v1(183.03,113.13)
  IN3 w0.127: 180.01,103.69 v1(180.31,103.39)
  BOTTOM w0.102: UV1.AH16 182.91,113.13 v1(183.03,113.13)
N21220354: length 31.7
  TOP w0.102: v1(167.64,101.18) 166.1,101.18 v2(165.02,100.1) 164.49,99.58 RV203.1
  IN3 w0.102: v1(171.35,118.74) 171.92,118.17 171.92,117.22 171.48,116.78 171.03,116.78 170.05,115.8 169.55,115.8 169.25,115.51 169.25,114.97 168.59,114.3 166.21,114.3 165.44,113.54 164.3,113.54 164.11,113.35
  IN3 w0.127: 164.11,113.35 163.38,112.62 163.38,110.5 162.27,109.39 162.27,108.39 167.64,103.02 v1(167.64,101.18)
  BOTTOM w0.102: UV1.Y29 171.66,119.05 v1(171.35,118.74)
N21246320: length 3.2
  BOTTOM w0.102: v2(174.92,188.62) 175.15,188.39 PR1211.2
  BOTTOM w0.254: PQ1201.1 173.92,187.46 PR1211.2
N21246524: length 3.6
  BOTTOM w0.102: PR1212.2 173.46,182.39 v2(173.66,182.19)
  BOTTOM w0.254: PQ1201.2 174.1,184.8 PC1214.1 PR1212.2
N21457125:
  vias: v2(23.59,85.6)
N22117330: length 7.4
  TOP w0.102: U1.1 15.79,107.55 16.23,107.11 R12.2 v1(17.05,107.11) ; v1(15.93,110.55) 15.93,111.12 15.69,111.36 U2.1
  IN3 w0.127: v1(17.05,107.11) 16.48,107.68 16.48,110.01 v1(15.93,110.55)
  BOTTOM w0.102: v1(15.93,110.55) 15.93,110.89 v2(15.78,111.05)
N22117472: length 5.9
  TOP w0.102: JCRT1.4 5.47,110.29 C8.1 v2(8.59,114.87)
N22117533: length 6.6
  TOP w0.102: JCRT1.11 7.81,103.42 8.64,104.25 12.7,104.25 T1.1
N22119803: length 2.5
  BOTTOM w0.102: U4.4 16.98,101.6 16.87,101.48 v2(16.22,101.48) 15.84,101.48 C89.1
N22119877: length 2.3
  BOTTOM w0.102: U4.3 16.39,101.2 16.16,100.96 R32.1
N22119883: length 8.5
  BOTTOM w0.102: R19.1 18.72,96.66 18.72,96.04 19.07,95.69 v2(20.41,95.69) 21.05,95.69 21.38,96.02 21.38,96.96 C46.1 22.03,97.7 21.5,98.22 20.97,98.22 20.82,98.37 20.82,98.93 20.85,98.96 U4.50
N22119919: length 2.5
  BOTTOM w0.102: R30.1 15.52,103.38 16.1,102.8 v2(16.35,102.8) U4.7
N22119921: length 3.8
  BOTTOM w0.102: U4.13 17.07,105.2 15.88,106.38 R26.1 v2(15.35,107.43)
N22119926: length 2.6
  BOTTOM w0.102: U4.10 16.75,104 16.56,104.18 v2(16.26,104.18) 16.07,104.18 R29.1
N22120195: length 2.4
  TOP w0.102: v1(26.25,104.27) T2.1
  BOTTOM w0.102: U4.32 26.12,104.4 v1(26.25,104.27)
N22120347: length 5.6
  BOTTOM w0.102: v2(24.76,95.51) 24.76,97.25 R35.2 25.24,100.07 24.92,100.4 U4.42
N22120749: length 4.8
  TOP w0.102: Q3.1 v2(17.57,116.84)
  TOP w0.508: Q3.1 20.35,116.05 20.35,114.63 R39.1
N22314596: length 2.9
  BOTTOM w0.102: UL1.26 38.75,81.37 40,80.12 T96.1
N22321388: length 90.9
  TOP w0.089: RE37.2 128.76,98.41 v1(129.51,99.16) v2(130.09,99.16)
  TOP w0.102: v1(188.19,54.34) 188.26,54.34 188.79,53.81 UE1.82
  IN1 w0.084: 131.57,97.6 131,97.6 129.51,99.1 v1(129.51,99.16)
  IN1 w0.127: v1(179.16,53.16) 177.87,54.46 177.87,56.41 177.41,56.87 177.41,58.2 174.87,60.74 174.87,63.88 174.32,64.42 174.32,70.82 169.49,75.66 159.86,75.66 149.65,85.87 147.62,85.87 139.38,94.12 136.02,94.12 132.54,97.6 131.57,97.6
  IN3 w0.127: v1(179.16,53.16) 179.36,53.36 183.34,53.36 184.32,54.34 v1(188.19,54.34)
N22941663: length 2.2
  TOP w0.102: RD18.2 58.81,12.87 v2(58.81,11.88) LED4.1
N22942544: length 2.3
  TOP w0.102: RD15.2 v2(42.14,10.74) LED2.1
N22942565: length 2.2
  TOP w0.102: RD16.2 v2(49.9,12.04) 49.9,10.74 LED3.2
N22942572: length 2.8
  TOP w0.102: RD17.2 48.13,12.94 48.03,12.84 v2(48.03,12.55) 48.03,11.61 LED3.3
N22942580: length 3.1
  TOP w0.102: LED1.1 33.67,10.74 RD14.2 33.74,11.4 v2(34.13,11.79)
N23098258: length 4.9
  BOTTOM w0.254: PU1000.2 38.76,114.11 38.98,114.32 v2(38.98,114.78) 38.27,115.49 PC1003.2 PR1001.2 PR1002.1
N23098273:
  vias: v1(37.49,111.25) v1(37.49,110.42) v1(37.49,109.6) v1(38.64,111.25) v1(38.64,110.42) v1(38.64,109.6) v2(43.84,108.52)
N23098353: length 4.3
  BOTTOM w0.254: PU1000.8 37.49,106.93 38.26,106.17 PR1004.1 PR1003.2 PC1004.1
N23623264: length 5.5
  TOP w0.102: v2(137.89,182.22) 138.59,182.22 139.24,182.87 PD2.3
  TOP w0.254: v1(138.55,184.08) 138.99,184.08 139.24,183.83 PD2.3
  BOTTOM w0.254: PD1.6 138.86,185.05 PR17.1 v1(138.55,184.08)
N25368131: length 6
  TOP w0.102: UV5.J13 169.11,142.82 169.11,141.32 169.7,140.73 170.47,140.73 v2(171.05,140.16) 172.11,139.1 RV25.2
N25669355: length 5
  BOTTOM w0.102: UV6.J13 189.64,142.74 189.64,140.75 v2(189.93,140.46) RV30.2
N26889205: length 2.3
  TOP w0.102: v2(171.03,118.23) 170.66,118.6 v1(170.66,118.7) 171.23,119.26 RV198.1
  BOTTOM w0.102: v1(170.66,118.7) 170.86,118.9 UV1.Y30
N32320781:
  vias: v2(138.59,162.08)
N32936693: length 4.5
  TOP w0.102: PQ706.1 135.79,167.57 135.7,167.48 133.99,167.48 v2(133.88,167.58)
  TOP w0.254: PQ706.1 135.79,169.68 PR720.2
N39186606: length 2.5
  TOP w0.102: v2(179.21,109.54) 178.89,109.87 v1(178.4,109.87) 178.07,110.2 RV125.1
  BOTTOM w0.102: UV1.AL21 177.91,110.29 178.34,109.87 v1(178.4,109.87)
N39195318: length 2.7
  TOP w0.102: v2(172.71,103.16) 172.71,103.87 RV123.1 173.12,104.85 v1(173,104.97)
  BOTTOM w0.102: v1(173,104.97) 172.66,105.31 UV1.AW28
N39348342: length 5
  BOTTOM w0.102: UV1.AW18 181.28,104.88 182.47,104.88 183.01,104.34 v2(183.01,103.72) 183.01,102.47 RV122.1
N39890903: length 23
  TOP w0.102: CV218.1 194.35,94.58 194.77,95 v1(195.23,95)
  IN3 w0.102: v1(187.65,110.69) 187.2,110.24 187.2,107.43 189.47,105.16 189.47,103.69
  IN3 w0.127: v1(195.23,95) 193.13,95 190.06,98.07 190.06,101.04 189.47,101.63 189.47,103.69
  BOTTOM w0.102: UV1.AK10 187.26,111.08 v1(187.65,110.69) ; v1(195.23,95) v2(195.89,95)
N39890907: length 2.1
  TOP w0.102: v2(192.15,93.5) 192.44,93.21 CV219.2 RV137.1
N39890909: length 2.1
  TOP w0.102: RV136.1 CV218.2 193.44,95.32 v2(193.35,95.41)
N39890911: length 3.8
  TOP w0.102: RV144.1 207.93,99.05 CV222.1 RV143.2 v2(209.96,97.77)
N39890927: length 22.1
  TOP w0.102: v1(190.87,92.81) 191.22,92.46 CV219.1
  IN3 w0.102: v1(186.88,110.7) 187,110.58 187,107.35 189.19,105.15 189.19,103.69
  IN3 w0.127: 189.19,103.69 189.19,101.46 189.8,100.85 189.8,97.97 191.03,96.74 191.03,95.64 191.67,95.01 191.67,93.61 v1(190.87,92.81)
  BOTTOM w0.102: UV1.AL10 187.26,110.32 186.89,110.7 v1(186.88,110.7) ; v1(190.87,92.81) v2(190.87,93.36)
N39986171: length 12.9
  BOTTOM w0.102: QV24.1 180.24,90.24 180.93,89.55 v2(184.59,89.55) 184.8,89.55 185.63,90.37 186.58,90.37 RV107.2 RV108.1
N39986181: length 4.5
  BOTTOM w0.102: v2(189,96.18) 189.26,95.93 RV108.2 189.24,94.81 CV103.1 188.06,94.69 QV22.2
N40812716: length 5.2
  TOP w0.102: v2(181.12,18.06) CR3.2
  TOP w0.305: CR3.2 180.14,19.35 179.48,20.01 179.23,20.01 178.32,20.92 UR1.6
N45520480: length 3.2
  TOP w0.102: RV206.2 174.55,125.78 v1(173.96,125.19) 173.96,125.21 v2(173.39,125.77)
  BOTTOM w0.102: v1(173.96,125.19) 173.78,125.19 173.46,125.51 UV1.M27
N46608735: length 2.5
  BOTTOM w0.254: PQ701.2 141.21,164.47 v2(141.79,163.89) PR701.1
N46608740: length 4.7
  BOTTOM w0.102: PQ701.4 139.33,166.51 138.08,165.26 138.08,164.32 v2(137.3,163.54)
N46608753: length 6.6
  BOTTOM w0.254: PC701.2 143.81,167 PC702.1 144.88,166.63 145.26,166.25 145.26,165.22 145.05,165.01 v2(144.82,165.01) 144,165.01 PR703.1 PR701.2
N46612327: length 3.5
  TOP w0.102: PR708.1 167.53,173.04 167.04,173.52 167.04,173.68 v2(166.66,174.06)
  TOP w0.254: PU701.13 167.99,172.72 PR708.1
N46612330: length 1.9
  TOP w0.254: PU701.12 v1(168.49,172.18) 168.49,172.96 PR710.1
N46660696: length 1.1
  TOP w0.102: PC520.2 v2(106.08,143.72)
N46662317: length 2.6
  TOP w0.102: v1(86.33,137.3) 85.59,137.3 v2(85.38,137.51)
  TOP w0.254: v1(86.33,137.3) 86.39,137.23 PR510.1
  BOTTOM w0.203: PU501.4 86.41,137.22 v1(86.33,137.3)
N46663656: length 4.8
  TOP w0.102: v1(86.34,136.3) 86.34,135.5 86.52,135.32 86.52,134.4 v2(86.4,134.28)
  TOP w0.254: v1(86.34,136.3) 86.38,136.34 PC504.1
  BOTTOM w0.203: v1(86.34,136.3) 86.45,136.42 PU501.2
  BOTTOM w0.254: PR516.2 85.81,135.77 v1(86.34,136.3)
N46665785: length 3.6
  BOTTOM w0.102: v2(94.74,131.58) 94.27,132.05 92.81,132.05 92.66,132.2 PR529.1
  BOTTOM w0.254: PR529.1 92.36,132.6 92.29,132.66 PC514.1
N46673636: length 6.6
  TOP w0.102: v1(93,142.38) 93,142.8 v2(93.08,142.88)
  IN1 w0.254: v1(96.43,144.21) 96.43,144.1 96.1,143.77 93.85,143.77 92.89,142.82 92.89,142.48 v1(93,142.38)
  BOTTOM w0.254: v1(96.43,144.21) 96.43,143.52 PH501.2 ; PR515.1 92.99,141.75 92.99,142.37 v1(93,142.38)
N46674251: length 19.1
  BOTTOM w0.254: PL502.2 102.77,140.15 102.33,140.6 102.33,144 100.83,145.49 95.07,145.49 v2(94.53,144.95) 93.56,143.98 PR518.2
N46860163: length 6.6
  TOP w0.102: PR713.2 173.18,171.65 v2(173.25,171.58)
  TOP w0.254: PR713.2 172.25,172.77 171.91,173.11 PQ708.1 171.23,173.11 170.02,171.91 170.02,171.91 169.7,171.59 169.7,170.44 PU701.10
N46975913: length 2.5
  BOTTOM w0.102: v2(119.25,140.34) 118.97,140.05 PR536.2
  BOTTOM w0.254: PR536.2 118.16,139.53 PC501.1
N46975982: length 1.5
  BOTTOM w0.203: PU502.6 116.07,140.43 116.45,140.05 PR536.1
N46976065: length 3.8
  BOTTOM w0.102: PC501.2 116.69,138.56 v2(115.68,137.54)
  BOTTOM w0.203: PU502.7 115.94,140.03 116.22,139.75 116.22,139.44 PC501.2
N47007806: length 2.4
  TOP w0.254: PR28.2 127.46,166.88 127.47,166.89 PC16.1 127.66,167.51 PQ2.3
N47007810: length 4.3
  TOP w0.102: PR29.1 127.65,170.6 v2(127.33,170.92)
  TOP w0.254: PR29.1 127.47,169.82 PC16.2 127.55,168.16 PQ2.2
N47007850: length 4.2
  TOP w0.254: PR33.2 131.47,166.27 132.35,166.27 132.48,166.4 v2(132.48,166.62) 132.48,167.21 PR31.1 131.8,167.7 131.35,168.16 PQ2.5
N47007898: length 3.8
  TOP w0.102: PR32.1 133.17,162.71 v2(133.4,162.47)
  TOP w0.254: PQ3.5 131.54,162.95 131.78,162.71 PR32.1 PC14.2
N47008006: length 1.4
  TOP w0.102: v2(127.57,176.41) 128.22,175.76 PQ1.6
N47008110: length 2.4
  TOP w0.254: PQ3.2 128.17,162.95 127.93,162.71 PR30.2 PC15.1
N47008134: length 7.4
  TOP w0.102: v2(130.46,183.16) 130.86,182.76 v1(130.97,182.76)
  TOP w0.254: v1(130.97,182.76) 131.03,182.7 PR6.2
  BOTTOM w0.254: v1(130.97,182.76) 130.71,182.51 PL2.2 128.97,182.66 PQ6.1
N47008301: length 1.4
  TOP w0.102: PQ4.1 128.17,178.73 v2(127.61,178.17)
N47305899: length 1.9
  TOP w0.102: PR805.1 211.17,61.28 v2(211.51,60.94)
N47415217: length 1.9
  TOP w0.102: PC104.2 133.35,15.79 v2(133.46,15.68)
  TOP w0.254: PR103.1 PC104.2
N47415258:
  vias: v2(134.4,20.73)
N47415272:
  vias: v2(120.27,20.97)
N47415370: length 1.9
  TOP w0.102: PC110.1 123.18,16.37 v2(122.25,16.37)
  TOP w0.254: PR111.2 PC110.1
N47417471: length 2.6
  BOTTOM w0.102: v2(105.35,23.37) 105.59,23.13 PC405.1
N47417524: length 3.4
  BOTTOM w0.102: PR405.2 106.07,26.97 105.54,26.43 v2(105.54,25.92)
  BOTTOM w0.508: PC401.1 106.94,26.38 PR405.2
N47420895:
  vias: v2(159.2,11.13)
N47445410: length 2.2
  TOP w0.203: PR114.1 v2(125.1,15.5) 125.57,15.5 125.73,15.67 PU100.19
N47894294: length 2
  BOTTOM w0.089: v2(99.01,94.49) 98.84,94.65 RC23.1 97.97,94.67 CC8.2
N47894380: length 2
  BOTTOM w0.089: RC24.1 93.51,95.52 CC9.2 93.5,96.07 v2(93.91,96.48)
N47894401: length 1.9
  BOTTOM w0.089: RC25.1 95.28,94.67 CC10.2 v2(95.28,96.53)
N47938591: length 9.5
  TOP w0.089: v1(125.05,107.06) 125.04,107.06 124.49,106.5 124.49,105.46 124.32,105.3 123.48,105.3 122.7,104.52 122.7,100.37 T118.1
  BOTTOM w0.089: v1(125.05,107.06) 124.62,107.48 UC1.AN10
N47938593: length 3
  TOP w0.089: T119.1 124.17,105.79 124.17,106.48 124.65,106.96 124.65,107.36 125,107.71 v1(125.06,107.71)
  BOTTOM w0.076: v1(125.06,107.71) 124.63,108.13 UC1.AM10
N47938689: length 1.1
  TOP w0.089: T120.1 121.85,123.55 v1(121.56,123.27)
  BOTTOM w0.089: v1(121.56,123.27) 121.89,122.94 UC1.E15
N47938710: length 3.2
  TOP w0.089: v1(122.53,123.29) 123.5,124.25 T121.1
  BOTTOM w0.089: v1(122.53,123.29) 122.88,122.94 UC1.E13
N47964855: length 5.3
  BOTTOM w0.076: UC1.L60 93.3,118.79 92.83,118.79 92.78,118.84 92,118.84 91.84,118.67 91.06,118.67 90.73,119.01 T153.1
N47964866: length 2.1
  TOP w0.254: v1(93.3,118.01) 93.3,118.02 92.64,118.67 T154.1
  BOTTOM w0.254: UC1.N60 93.6,118.31 v1(93.3,118.01)
N47964871: length 1.8
  TOP w0.109: T155.1 115.89,114.73 v1(116.14,114.48)
  BOTTOM w0.076: v1(116.14,114.48) 116.55,114.88 UC1.W23
N47964873: length 1.7
  TOP w0.089: v1(116.79,114.48) 117.21,114.89 T156.1
  BOTTOM w0.076: UC1.Y22 v1(116.79,114.48)
N47964879: length 7.3
  BOTTOM w0.076: 91,103.9 91.95,103.9 UC1.AV62
  BOTTOM w0.102: 91,103.9 88.79,101.69 T157.1
N47964884: length 6.6
  BOTTOM w0.076: UC1.D58 94.94,123.47 94.63,123.78 94.63,124.07 94.73,124.17 94.73,124.35 94.64,124.44 94.64,124.72 94.71,124.78 94.71,124.93 94.67,124.97 94.67,125.27 94.81,125.41 94.81,125.94 93.63,127.12 93.63,128.45 T158.1
N47965485: length 9.1
  BOTTOM w0.102: UC1.AV63 91.22,104.23 91.08,104.09 90.92,104.09 88.46,101.63 88.46,97.77 T146.1
N47965487: length 10.5
  BOTTOM w0.089: 88,99.65 88,101.74
  BOTTOM w0.102: T147.1 88,96.77 88,99.65 ; UC1.AU63 91.14,104.89 88,101.74
N47965489: length 1.3
  TOP w0.089: T160.1 119.8,117.61 v1(119.71,117.53)
  BOTTOM w0.076: v1(119.71,117.53) 119.3,117.53 UC1.P20
N47965491: length 1.3
  TOP w0.089: T162.1 119.88,116.12 v1(119.49,116.51)
  BOTTOM w0.076: v1(119.49,116.51) 119.1,116.9 UC1.R20
N47965493: length 5
  BOTTOM w0.102: UC1.A5 127.72,125.72 129.14,127.14 130.01,127.14 131.35,128.47 T159.1
N47965495: length 3.4
  BOTTOM w0.102: UC1.C63 91.56,124.25 91.17,124.64 89.23,124.64 T148.1
N47965502: length 3.4
  BOTTOM w0.076: T161.1 132.28,123.04 UC1.E1
N47965509: length 4.3
  BOTTOM w0.076: 89.95,124.44 90.99,124.44 91.51,123.91 92.04,123.91 UC1.C62
  BOTTOM w0.089: 88.91,124.35 89.01,124.44 89.95,124.44
  BOTTOM w0.102: T149.1 88.91,124.35
N47965511: length 4.5
  BOTTOM w0.076: UC1.D1 132.1,123.7 132.76,124.36 134.08,124.36 T163.1
N47965522: length 4.7
  BOTTOM w0.076: 104.54,128.7 103.98,128.14 103.98,126.4 104.7,125.68 104.7,125.44 104.41,125.15 UC1.B43
  BOTTOM w0.102: T150.1 104.54,128.9 104.54,128.7
N47965524: length 1.8
  TOP w0.089: T164.1 117.95,120.53 118.53,120.53 v1(118.66,120.66)
  BOTTOM w0.089: UC1.J20 118.78,120.66 v1(118.66,120.66)
N47965529: length 2.1
  BOTTOM w0.076: UC1.A51 99.39,126.88 T151.1
N47965534: length 4.1
  BOTTOM w0.076: UC1.B51 99.39,125.15 99.98,125.73 T152.1
N47965536: length 1.1
  TOP w0.089: v1(119.66,121.32) 119.87,121.32 T165.1
  BOTTOM w0.076: v1(119.66,121.32) 119.99,120.99 UC1.H18
N48037563: length 4.9
  TOP w0.102: RD6.2 103.96,68.78 v1(104.04,68.7) 104.74,68.7 v2(104.89,68.55)
  BOTTOM w0.102: v1(104.04,68.7) 103.74,68.7 103,69.44 JDIMM1.197
N48037565: length 5.6
  TOP w0.102: RD7.2 104,67.89 v1(104.04,67.94) 104.04,67.31 v2(104.38,66.97)
  BOTTOM w0.102: v1(104.04,67.94) 104.49,68.38 104.49,70.18 104.2,70.46 JDIMM1.201
N48039107: length 5.8
  TOP w0.102: RD4.1 83.46,63.42 CD22.1 CD21.1 81.69,61.99 81.5,61.8 v1(81.5,61.41) v2(81.5,60.81)
  BOTTOM w0.102: v1(81.5,61.41) 81.5,61.8 81.7,62 JDIMM1.126
N48051997: length 5.3
  TOP w0.102: 160.3,61.55 v2(160.3,60.84)
  TOP w0.508: RD10.1 162.06,62.55 CD53.1 CD52.1 160.3,61.55 v1(160.25,61.5)
  BOTTOM w0.356: v1(160.25,61.5) JDIMM2.126
N48052813: length 7.8
  TOP w0.102: v1(182.59,67.48) 183.13,68.02 v2(183.13,68.88) 183.13,70.13 RD13.1
  BOTTOM w0.102: JDIMM2.197 181.55,70.04 182.03,69.56 182.03,68.04 v1(182.59,67.48)
N48052822: length 7
  TOP w0.102: v2(183.3,67.29) 182.98,67.29 v1(182.59,66.9) 182.59,65.94 RD12.1
  BOTTOM w0.102: v1(182.59,66.9) 183.04,67.34 183.04,69.71 182.75,69.99 JDIMM2.201
N48120577: length 2.8
  TOP w0.102: RX5.2 199.74,166.61 200.5,166.61 201.27,167.38 UX4.12
N55155843: length 2.5
  TOP w0.102: QX1.1 217.04,176.27 RX3.2 218.09,175.53 v2(218.42,175.2)
N56393123: length 4.8
  BOTTOM w0.102: v2(33.98,78.95) 33.98,79.2 35.07,80.29 RL31.2
  BOTTOM w0.203: 36.5,81.53 36.75,81.78 UL1.31
  BOTTOM w0.254: RL31.2 35.08,80.65 35.46,81.03 35.46,81.12 35.76,81.42 36.39,81.42 36.5,81.53
N56393790: length 4.6
  BOTTOM w0.102: T94.1 39.67,79.61 39.67,80.06 38.35,81.38 UL1.27
N56393809: length 1.7
  BOTTOM w0.102: UL1.25 39.15,81.76 39.8,81.11 T95.1
N60531222: length 72.9
  TOP w0.102: v1(142.34,110.8) 142.75,110.39 143.58,110.39 144.01,109.97 144.38,109.97 145.61,111.2 148.11,111.2 149.72,112.81 149.72,115.52 149.23,116.02 149.23,117.58 145.55,121.26 145.55,125.11 v2(145.92,125.49) 146.43,126 v1(146.43,126.5)
  IN1 w0.084: 136.53,125.81 135.66,125.81 135.28,126.18 123.37,126.18 122.71,126.85 122.71,128.51 120.97,130.25 116.36,130.25 114.9,128.79 112.3,128.79 112.11,128.6 112.11,125.55 111.6,125.04 109.25,125.04 v1(108.58,125.72)
  IN1 w0.127: 136.53,125.81 137.89,125.81 138.17,125.54 145.47,125.54 146.43,126.49 v1(146.43,126.5)
  BOTTOM w0.076: 108.74,125.68 108.87,125.55 108.97,125.45 109.02,125.29 109.02,125.18 108.98,125.06 108.97,125.03 108.97,124.84 109.01,124.69 109.11,124.54 UC1.C35
  BOTTOM w0.089: v1(108.58,125.72) 108.7,125.72 108.74,125.68
  BOTTOM w0.102: v1(142.34,110.8) 142.34,110.8 142.02,111.12 142.02,111.23 142.08,111.29 RP41.1
N60531228: length 70.6
  TOP w0.102: v1(142.97,110.8) 144.89,110.8 145.52,111.43 147.64,111.43 148.84,112.63 148.84,117.64 145.32,121.17 145.32,121.65 145.1,121.87 v2(145.1,122.72) 145.1,125.63 145.84,126.38 v1(145.84,126.5)
  IN1 w0.084: v1(109.09,126.06) 109.94,125.21 111.53,125.21 111.93,125.62 111.93,128.67 112.23,128.96 114.83,128.96 116.29,130.42 121.05,130.42 122.88,128.59 122.88,126.92 123.44,126.36 135.54,126.36 135.83,126.07 136.69,126.07
  IN1 w0.127: v1(145.84,126.5) 145.13,125.79 138.27,125.79 138,126.07 136.69,126.07
  BOTTOM w0.076: UC1.C34 109.71,124.38 109.54,124.55 109.37,124.55 109.16,124.76 109.13,124.86 109.13,125 109.15,125.05 109.16,125.07 109.19,125.15 109.19,125.32 109.11,125.54 109.11,125.56
  BOTTOM w0.089: 109.11,125.56 109.11,126.04 v1(109.09,126.06)
  BOTTOM w0.102: v1(142.97,110.8) 142.97,111.45 142.63,111.79 RP41.2
N60531230: length 21.2
  TOP w0.102: v2(141.86,111.33) 141.76,111.23 v1(141.76,110.8)
  IN1 w0.084: v1(125.78,110.18) 126.3,110.69 128.17,110.69 128.51,111.03 129.34,111.03 130.6,109.78 134.65,109.78 134.88,110 136.41,110
  IN1 w0.127: 136.41,110 136.76,109.66 137.54,109.66 138.01,110.13 141.09,110.13 141.76,110.79 v1(141.76,110.8)
  BOTTOM w0.089: UC1.AK8 125.99,109.12 125.99,109.95 125.78,110.16 v1(125.78,110.18)
  BOTTOM w0.102: RP41.3 141.96,112.29 141.82,112.15 141.82,111.78 141.76,111.71 v1(141.76,110.8)
N60531232: length 25.1
  TOP w0.102: v1(141.17,110.8) 140.67,110.8 v2(140.15,110.28)
  IN1 w0.084: v1(125.47,109.16) 125.07,109.16 124.74,109.48 124.74,109.55 124.74,109.56 124.74,110.1 124.78,110.15 124.78,110.92 125.45,111.59 129.03,111.59 130.67,109.95 134.58,109.95 134.81,110.17 136.3,110.17 137.14,111.01 137.61,111.01
  IN1 w0.127: v1(141.17,110.8) 140.96,111.01 137.61,111.01
  BOTTOM w0.089: v1(125.47,109.16) 125.97,108.65 UC1.AL8
  BOTTOM w0.102: RP41.4 141.83,112.79 141.32,112.28 141.32,110.95 v1(141.17,110.8)
N60754677: length 5.5
  TOP w0.089: 88.91,122.52 89.42,122.52 89.79,122.15 89.79,121.64 v1(89.8,121.63)
  TOP w0.102: T111.1 88.91,122.52
  BOTTOM w0.076: v1(89.8,121.63) 90.2,121.23 90.72,121.23 90.8,121.31 91.3,121.31 91.38,121.23 91.53,121.09 91.77,121.09 91.94,121.26 91.94,121.43 92.18,121.67 92.7,121.67 UC1.H61
N60754679: length 4.3
  BOTTOM w0.076: UC1.H62 91.85,120.93 91.85,120.93 91.84,120.92 91.46,120.92 91.31,121.07 91.24,121.14 90.91,121.14 90.83,121.07 89.28,121.07 89.05,121.29
  BOTTOM w0.089: 88.91,121.43 89.05,121.29
  BOTTOM w0.102: T112.1 88.61,121.73 88.91,121.43
N60754681: length 1.4
  TOP w0.089: v1(94.67,120.23) 94.44,120 T113.1
  BOTTOM w0.076: UC1.K59 94.35,119.92 v1(94.67,120.23)
N60754683: length 2.1
  TOP w0.089: v1(90.39,121.64) 90.52,121.76 T114.1
  BOTTOM w0.076: UC1.H63 91.55,121.48 90.55,121.48 v1(90.39,121.64)
N60754685: length 1.4
  TOP w0.089: T115.1 93.91,119.43 v1(93.91,119.49)
  BOTTOM w0.076: v1(93.91,119.49) 93.91,119.61 UC1.K60
N60754687: length 2.7
  TOP w0.089: v1(92.65,121) 93.07,120.58 94.36,120.58 T116.1
  BOTTOM w0.076: UC1.J61 92.95,120.7 v1(92.65,121)
N60931942: length 4.6
  BOTTOM w0.076: UC1.AF2 130.07,112.04 130.08,112.04 130.09,112.05 130.4,112.05 130.55,112.2 131.91,112.2 132.43,112.72 T97.1
N60931944: length 5
  BOTTOM w0.076: T99.1 132.91,111.45 130.54,111.45 130.4,111.3 130.09,111.3 129.92,111.14 129.14,111.14 129.04,111.23 128.65,111.23 UC1.AF4
N60931946: length 6.7
  BOTTOM w0.076: UC1.AD2 129.86,112.35 130.33,112.81 131.51,112.81 132.03,113.33 132.03,113.54 132.16,113.66 132.73,113.66 133.19,113.21 134.93,113.21 T98.1
N61580896: length 5.7
  TOP w0.102: v2(180.24,60.35) 180.42,60.17 Q2307.1 182.97,61.22 183.16,61.41 183.48,61.41 183.8,61.1 R2314.2
N61580898: length 4.4
  TOP w0.102: v2(148.48,123.87) 147.3,122.69 R2315.2 146.9,121.4 147.13,121.17 Q2308.1
N63469417: length 3.8
  TOP w0.102: v2(34.21,26.52) 33.93,26.23 RA81.2 CA69.1 CA65.2 RA79.1
N63469524: length 10.6
  TOP w0.254: v1(22.58,25.13) 22.71,25.26 22.71,25.27 23.67,26.24 23.82,26.24 23.97,26.38 23.97,27.14 24.41,27.58 25.61,27.58 CA68.2
  BOTTOM w0.203: RA82.1 22.61,21.03 23.03,21.45 23.03,22.87 v2(22.93,22.97) 22.7,23.2 22.7,25.02 v1(22.58,25.13)
N63469526: length 8.6
  TOP w0.254: CA67.2 24.97,27 24.35,26.37 24.35,26.23 23.98,25.85 23.83,25.85 23.23,25.26 v1(23.23,25.11)
  BOTTOM w0.203: v1(23.23,25.11) 23.15,25.03 v2(23.15,24.6) 23.15,23.29 23.36,23.09 23.36,21.31 22.75,20.7 22.38,20.7 RA80.1
N63469613: length 3.2
  TOP w0.102: UA1.12 30.47,22.85 30.83,23.2 30.83,23.89 v2(31.18,24.24) 31.46,24.52 CA65.1
N63469617: length 2.1
  TOP w0.203: RA51.1 29.68,24.9 29.28,24.5 UA1.13
N63469687: length 3.1
  TOP w0.102: v2(22.02,22.51) 22.42,22.11 v1(22.51,22.11)
  TOP w0.203: UA1.28 23.71,21.65 23.64,21.72 23.17,21.72 22.78,22.11 v1(22.51,22.11)
  BOTTOM w0.254: v1(22.51,22.11) CA23.2
N63469697: length 2.3
  TOP w0.203: UA1.15 28.48,24.36 28.51,24.38 v2(28.51,24.83) 28.51,25.88 RA153.2
N63469703: length 3.6
  TOP w0.102: v2(22.28,17) 22.46,17.18 CA24.1 22.77,17.67 UA1.37
N63469709: length 3.9
  TOP w0.102: v2(20.63,17.71) 21.28,17.71 CA24.2 22.1,18.54 22.37,18.54 22.57,18.74 23.4,18.74 23.5,18.85 UA1.35
N63469711: length 2.2
  TOP w0.102: UA1.34 23.58,19.25 23.47,19.14 v2(22.93,19.14) 22.15,19.14 CA25.2
N63469717: length 4.4
  TOP w0.203: UA1.27 23.32,22.05 22.66,22.71 v1(22.5,22.71)
  BOTTOM w0.102: v2(21.12,24.65) 21.81,23.97 CA62.2
  BOTTOM w0.254: CA62.2 21.89,23.31 v1(22.5,22.71)
N63469723: length 5.1
  TOP w0.203: v1(24.53,16.6) 24.86,16.26 25.52,16.26 25.78,16.51 25.78,17 25.68,17.09 UA1.39
  BOTTOM w0.102: v2(22.41,15.96) CA63.2
  BOTTOM w0.203: v1(24.53,16.6) 23.89,15.96 CA63.2
N63469729: length 6.2
  TOP w0.102: v2(35.04,22.64) 34.91,22.51 34.91,21.72 34.47,21.28 CA64.2 34.08,20.98 31.65,20.98 31.52,20.85 UA1.7
N63469750: length 2.2
  TOP w0.102: RA130.2 31.78,21.47 31.55,21.25 v2(31.22,21.25) UA1.8
N63642793: length 44.2
  TOP w0.089: 136.24,101.44 136.13,101.55 136.13,103.3 v2(133.47,105.96) 132.87,106.56 129.63,106.56 129.36,106.84 127.24,106.84 127.24,106.84 126.81,106.84 125.95,107.7 125.95,108.94 125.87,109.01 125.87,109.74 126.16,110.02 126.16,110.36 125.75,110.76 123.99,110.76 123.79,110.56 123.79,110.17 v1(123.4,109.77)
  TOP w0.102: C51.1 149.57,105.45 R264.2 149.57,104.46 150.09,103.93 150.65,103.93 150.84,103.74 150.84,99.45 149.97,98.58 139.53,98.58 139.14,98.97 138.71,98.97 136.24,101.44
  BOTTOM w0.089: UC1.AH11 123.71,110.09 v1(123.4,109.77)
N63643467: length 1
  TOP w0.089: T53.1 122.49,120.67 v1(122.5,120.67)
  BOTTOM w0.089: UC1.J13 122.9,120.34 122.57,120.67 v1(122.5,120.67)
N63643476: length 1.1
  TOP w0.089: T55.1 122.62,109.61 v1(122.62,109.76)
  BOTTOM w0.254: v1(122.62,109.76) 122.94,110.09 UC1.AH13
N63643505: length 1.9
  TOP w0.089: T56.1 125.31,114.54 v1(125.87,113.98)
  BOTTOM w0.254: v1(125.87,113.98) 125.69,113.81 UC1.AB8
N63643514: length 2.2
  TOP w0.089: v1(124.03,112.44) 122.68,112.44 T58.1
  BOTTOM w0.089: UC1.AD10 124.15,112.56 v1(124.03,112.44)
N63643523: length 1.1
  TOP w0.089: T59.1 125.57,113.36 v1(125.89,113.04)
  BOTTOM w0.089: v1(125.89,113.04) 125.69,112.84 UC1.AD8
N63656577: length 1.8
  TOP w0.089: v1(116.14,113.67) 116.5,113.31 T38.1
  BOTTOM w0.254: UC1.AB23 116.55,113.26 116.14,113.67 v1(116.14,113.67)
N63657072: length 3.9
  BOTTOM w0.076: UC1.P60 93.31,117.3 92.83,117.3 92.79,117.34 92,117.34 91.84,117.17 91.53,117.17 91.4,117.05 90.15,117.05 T39.1
N63657081: length 1.9
  TOP w0.089: v1(92.65,118.01) 92.29,118.01 T40.1
  BOTTOM w0.089: v1(92.65,118.01) 92.95,117.71 UC1.P61
N63657090: length 1.2
  TOP w0.254: v1(94.64,118.76) 94.78,118.62 T41.1
  BOTTOM w0.254: v1(94.64,118.76) 94.31,118.42 UC1.N59
N63657099: length 5.2
  BOTTOM w0.076: UC1.N61 92.7,118.67 92.18,118.67 91.94,118.44 91.94,118.26 91.77,118.09 91.53,118.09 91.5,118.11 91.3,118.31 90.27,118.31 90.14,118.18 89.06,118.18 T42.1
N63657120: length 1.5
  TOP w0.089: v1(93.95,116.51) 93.95,116.76 T43.1
  BOTTOM w0.089: UC1.T59 94.25,116.81 v1(93.95,116.51)
N63657126: length 2.4
  TOP w0.089: v1(93.99,112.02) 93.43,112.57 T44.1
  BOTTOM w0.254: UC1.AD60 93.6,112.4 v1(93.99,112.02)
N63657135: length 1.1
  TOP w0.089: T45.1 94.33,112.47 v1(94.67,112.13)
  BOTTOM w0.254: v1(94.67,112.13) 94.37,112.42 UC1.AD59
N63657146: length 1.8
  TOP w0.254: v1(94.58,113.48) 95.13,113.48 T46.1
  BOTTOM w0.254: UC1.AA59 94.58,113.59 v1(94.58,113.48)
N63657155: length 4.1
  BOTTOM w0.076: T47.1 90.71,111.26 91.3,111.26 91.39,111.18 91.75,111.18 91.8,111.2 91.91,111.25 93.25,111.25 UC1.AE60
N63657164: length 1.1
  TOP w0.254: T48.1 93.95,114.11 v1(93.95,113.51)
  BOTTOM w0.254: UC1.AC59 93.95,113.4 v1(93.95,113.51)
N63657173: length 1.8
  TOP w0.089: T49.1 93.8,111.26 94.48,111.26 v1(94.64,111.11)
  BOTTOM w0.254: v1(94.64,111.11) 94.59,111.06 UC1.AG58
N63657182: length 2.1
  TOP w0.089: v1(95.46,116.83) 94.96,116.83 T50.1
  BOTTOM w0.076: UC1.U59 94.46,116.09 94.87,116.5 95.13,116.5 v1(95.46,116.83)
N63657191: length 1.1
  TOP w0.089: T51.1 94.58,115.14 v1(94.58,115.01)
  BOTTOM w0.089: v1(94.58,115.01) 94.25,115.34 UC1.V59
N64564173: length 1.7
  TOP w0.102: v2(183.52,167.5) 183.67,167.66 PR1101.2
N64564191: length 1.9
  TOP w0.102: v2(180.34,168.62) 180.24,168.72 PR1104.2
N64734520: length 3.8
  TOP w0.089: v1(125.96,111.13) 125.92,111.09 123.75,111.09 T107.1
  BOTTOM w0.089: UC1.AJ7 126.17,109.87 126.17,110.34 126,110.51 126,111.09 v1(125.96,111.13)
N64734538: length 1.2
  TOP w0.089: v1(127.42,109.27) 128.06,109.27 T105.1
  BOTTOM w0.089: v1(127.42,109.27) 127.42,108.83 UC1.AL5
N64734540: length 5.6
  BOTTOM w0.076: UC1.AP4 128.56,106.39 128.86,106.68 129.1,106.68 129.14,106.64 129.92,106.64 130.09,106.81 130.55,106.81 130.65,106.71 133.25,106.71 T106.1
N93761952: length 6
  BOTTOM w0.102: RV163.2 201.9,130.16 201.9,130.88 v2(202.4,131.39) 203.67,132.66 205.12,132.66 UV8.J13
N93762059: length 8.1
  TOP w0.102: UV7.J13 205.13,132.68 203.95,132.68 203.23,131.96 203.23,129.16 v2(202.67,128.59) RV162.2
N93819115: length 5
  BOTTOM w0.102: UV10.J13 204.92,112.27 203.66,112.27 v2(202.29,110.89) 201.95,110.55 RV171.2
N93820861: length 5
  TOP w0.102: UV9.J13 204.94,112.28 202.96,112.28 v2(202.35,111.68) RV169.2

## Copper pours and planes (outline as drawn)
1.35V_B+ on BOTTOM (solid shape): 158.91,18.6 167.18,18.6 167.73,18.04 167.73,15.06 167.35,14.68 162.65,14.68 162.59,14.74 162.59,15.25 162.27,15.57 156.37,15.57 155.79,16.14 155.79,18.55 156,18.76 158.75,18.76
3/5V_B+ on TOP (solid shape): 131.98,28.97 131.98,26.2 131.79,26.01 130.53,26.01 129.96,25.44 129.95,25.44 129.48,24.97 127.85,24.97 127.6,25.22 126.14,25.22 125.89,25.47 125.89,25.73 125.53,26.08 123.09,26.08 122.89,26.29 122.89,29.02 123.41,29.54 131.41,29.54
3/5V_B+ on BOTTOM (solid shape): 129.47,29.26 129.47,25.25 129.19,24.97 126.67,24.97 125.9,25.73 125.9,29.36 126.08,29.54 129.19,29.54
3VALW_PCH on TOP (solid shape): 141.48,26.24 141.48,25 141.25,24.78 141.25,23.82 141.19,23.76 139.25,23.76 138.74,24.27 138.74,26.13 138.94,26.32 141.4,26.32
3VS on BOTTOM (solid shape): 95.91,32.97 95.91,30.11 95.85,30.05 93.31,30.05 92.99,30.36 92.99,30.89 93.54,30.89 93.54,31.45 92.99,31.45 92.99,31.69 93.53,31.69 93.53,32.24 92.99,32.24 92.99,33.41 93.06,33.47 95.41,33.47
5VS on BOTTOM (solid shape): 100.23,33.09 100.23,32.22 99.71,32.22 99.71,31.72 100.23,31.72 100.23,31.42 99.71,31.42 99.71,30.92 100.23,30.92 100.23,30.3 99.98,30.05 97.44,30.05 97.31,30.17 97.31,33.09 97.5,33.28 100.04,33.28
+0.675VS on TOP (solid shape): 105.93,73.12 105.93,62.4 105.68,62.15 104.83,62.15 104.66,62.32 104.66,68.19 104.7,68.27 104.8,68.28 105.17,68.5 104.88,68.83 104.86,68.83 104.81,68.88 104.66,68.88 104.66,70.32 104.75,70.32 104.87,70.44 104.87,73.22 105.82,73.22
+0.675VS on TOP (solid shape): 184.48,74.32 184.48,64.65 185.26,63.87 185.26,62.3 185.08,62.12 184.24,62.12 184.23,62.11 183.38,62.11 183.21,62.28 183.21,66.91 183.24,66.98 183.31,67.01 183.58,67.29 183.31,67.57 183.24,67.6 183.21,67.67 183.21,67.85 183.31,67.95 183.31,68.66 183.41,68.88 183.31,69.09 183.31,70.2 183.21,70.3 183.21,74.67 183.23,74.69 184.12,74.69
+0.675VS on BOTTOM (solid shape): 184.38,72.34 184.38,62.49 184.06,62.17 183.54,62.17 183.46,62.25 183.46,69.72 183.16,70.03 183.16,72.42 183.27,72.53 184.2,72.53
+0.675VS on BOTTOM (solid shape): 105.83,72.38 105.83,62.53 105.51,62.21 104.99,62.21 104.91,62.29 104.91,69.76 104.67,70.01 104.67,70.25 104.61,70.3 104.61,72.46 104.72,72.57 105.65,72.57
+0.675VS on BOTTOM (solid shape): 156.05,30.11 156.05,29.16 155.6,28.71 155.28,28.71 155.28,29.26 154.79,29.26 154.79,28.71 154.27,28.71 154.09,28.9 154.09,30.06 154.39,30.36 155.79,30.36
+0.675VS on IN2 (solid shape): 155.84,32.38 155.84,29.62 155.51,29.3 154.5,29.3 154.19,29.61 154.19,32.27 154.47,32.55 155.68,32.55
+0.675VS on IN2 (solid shape): 157.36,57.09 157.36,54.32 157.03,54 156.02,54 155.71,54.31 155.71,56.97 155.98,57.25 157.19,57.25
+0.675VS on IN3 (solid shape): 106.11,66.56 106.11,64.31 106.02,64.22 105.07,64.22 104.9,64.38 104.9,66.45 105.15,66.7 105.97,66.7
+0.675VS on IN3 (solid shape): 184.56,66.05 184.56,64.63 183.89,63.95 183.1,63.95 182.97,64.08 182.97,66.18 183.16,66.37 184.24,66.37
+0.675VS on IN3 (solid shape): 158.05,57.01 158.05,56.17 157.91,56.03 155.59,56.03 155.5,56.12 155.5,57.12 155.63,57.25 157.8,57.25
+0.675VSP on BOTTOM (solid shape): 157.33,29.28 157.33,25.93 157.44,25.81 157.44,25.6 157.38,25.54 156.49,25.54 156.37,25.66 156.37,26.19 155.86,26.69 154.28,26.69 154.15,26.82 154.15,28.34 154.33,28.52 154.95,28.52 154.95,29.1 155.12,29.1 155.12,28.52 155.66,28.52 155.68,28.53 156.49,29.35 157.26,29.35
+1.2VSP_B+ on TOP (solid shape): 178.52,176.39 179.15,176.39 179.25,176.29 179.25,174.85 178.91,174.51 178.91,173.11 178.85,173.05 178.39,173.05 178.07,173.37 175.11,173.37 174.97,173.5 174.97,175.33 174.59,175.71 173.89,175.71 173.77,175.84 173.77,177.68 174.08,178 176.92,178
+1.5VS on TOP (solid shape): 113.03,33.82 113.03,31.75 112.93,31.65 110.93,31.65 110.52,32.05 110.52,33.65 110.78,33.9 112.95,33.9
+1.05VS on TOP (solid shape): 148.67,127.63 148.67,125.24 147.59,124.17 147.59,123.81 147.47,123.69 146.38,123.69 146.23,123.84 146.23,124.69 147.24,125.69 147.24,127.62 147.38,127.76 148.53,127.76
+1.05VS on TOP (solid shape): 91.53,130.46 91.53,129.87 91.34,129.68 90.92,129.68 90.7,129.9 90.7,130.44 89.44,131.71 88.35,131.71 87.96,131.32 87.15,131.32 86.82,131.65 86.82,132.99 86.9,133.07 88.93,133.07
+1.05VS on TOP (solid shape): 64.16,98.05 64.16,94.12 63.79,93.74 61.95,93.74 61.72,93.97 61.72,94.63 61.83,94.74 61.94,95.07 61.72,95.35 61.72,98.09 61.81,98.18 64.04,98.18
+1.05VS on TOP (solid shape): 142.59,139.96 142.59,139.58 142.65,139.52 144.68,139.52 144.75,139.58 144.75,140.03 144.81,140.09 146.14,140.09 146.46,139.77 146.46,136.92 145.57,136.03 141.25,136.03 141.24,136.04 137,136.04 136.23,136.81 131.87,136.81 131.84,136.85 131.84,137.41 131.93,137.51 139.79,137.51 140.55,138.27 140.55,139.46 141.19,140.09 142.46,140.09
+1.05VS on TOP (solid shape): outline of 465 points within 119.04,93.77 121.19,113.9
+1.05VS on BOTTOM (solid shape): 88.1,132.85 88.1,131.71 87.98,131.58 86.77,131.58 86.58,131.77 86.58,132.85 86.64,132.92 88.04,132.92
+1.05VS on BOTTOM (solid shape): 149.1,135.03 149.1,126.4 148.68,125.98 147.43,125.98 147.05,126.36 147.05,132.55 142.62,136.98 142.62,138.83 142.92,139.13 145,139.13
+1.5VS on BOTTOM (solid shape): 113.55,34.13 113.55,31.86 113.33,31.63 112.78,31.63 112.78,32.18 112.24,32.18 112.24,31.63 111.99,31.63 111.99,32.18 111.43,32.18 111.43,31.63 111.1,31.63 110.95,31.79 110.95,34.22 111.27,34.55 113.13,34.55
+1.05VS on BOTTOM (solid shape): 86.05,112.62 86.29,112.62 86.37,112.53 86.37,112.37 86.56,112.19 87.42,112.19 87.47,112.13 87.47,111.01 87.35,110.89 86.11,110.89 86.04,110.96 86.04,111.23 85.93,111.34 85.41,111.34 85.25,111.51 85.25,112.55 85.37,112.68 85.99,112.68
+1.05VS on BOTTOM (solid shape): 85.72,123.78 85.72,121.91 85.29,121.48 81.79,121.48 81.26,120.96 81.26,120.38 81.18,120.29 80.85,120.29 80.46,120.68 80.46,120.86 80.21,121.11 78.83,121.11 78.58,121.35 78.58,122.66 78.8,122.87 80.1,122.87 80.64,122.33 83.33,122.33 84.84,123.85 85.65,123.85
+1.05VS on BOTTOM (solid shape): 121.54,142.46 121.54,140.68 121.73,140.49 123,140.49 123.22,140.71 123.22,141.48 123.36,141.62 124.34,141.62 124.41,141.54 124.41,138.07 124.29,137.96 123.47,137.96 123.42,138.01 123.42,138.88 123.3,139.01 120.79,139.01 120.62,138.84 120.62,137.06 120.26,136.69 116.37,136.69 116.26,136.8 116.26,137.83 116.42,138 117.47,138 120.4,140.92 120.4,142.36 120.62,142.58 121.42,142.58
+1.5VS on IN1 (solid shape): 113.06,34.39 113.06,32.39 112.93,32.25 109.86,32.25 109.53,32.58 109.53,34.68 109.69,34.84 112.61,34.84
+1.5VS on IN2 (solid shape): outline of 83 points within 95.01,148.67 115.49,149.86
+1.05VS on IN2 (solid shape): outline of 3111 points within 62.88,96.78 87.97,135.68
+1.05VS on VCC: 126.37,108.91 125.23,110.06 117.48,110.06 116.93,110.61 116.93,139.48 119.7,142.25 125.4,142.25 128.26,139.39 145.02,139.39 146.08,138.34 146.08,128.89 142.48,125.3 138.48,125.3 132.81,119.62 132.81,108.91
+1.05VS_APLLOPI on BOTTOM (solid shape): 126.78,141.5 126.78,135.49 126.54,135.25 124.79,135.25 124.65,135.39 124.65,139.9 124.97,140.23 124.97,141.58 125.12,141.73 126.55,141.73
+1.05VS_ASATA3PLL on BOTTOM (solid shape): 126.33,134.69 126.33,132.59 126.19,132.45 124.89,132.45 124.72,132.62 124.72,134.71 124.95,134.94 126.08,134.94
+1.05VS_ASATA3PLL on BOTTOM (solid shape): 124.55,142.31 124.55,141.92 124.4,141.77 123.22,141.77 123.09,141.64 123.09,140.83 122.97,140.7 122.09,140.7 121.98,140.8 121.98,142.5 122.05,142.57 124.3,142.57
+1.05VS_ASATA3PLL on IN3 (solid shape): 125.37,142.23 125.37,141.21 125.3,141.14 123.62,141.14 123.42,141.33 123.42,142.22 123.54,142.33 123.56,142.36 125.24,142.36
+1.05VS_ASATA3PLL on IN3 (solid shape): 126.66,135.73 126.66,132.98 126.65,132.95 126.63,132.9 126.63,132.86 126.63,132.81 126.63,132.76 126.65,132.71 126.66,132.68 126.66,131.52 125.25,130.11 125.25,128.92 125.38,128.79 125.38,128.29 125.19,128.1 124.83,128.1 124.23,128.69 124.23,131.01 124.64,131.42 124.64,131.56 125.62,131.56 125.62,131.51 125.63,131.45 125.64,131.4 125.67,131.36 125.7,131.32 125.73,131.28 125.78,131.25 125.82,131.23 125.87,131.21 125.92,131.2 125.98,131.2 126.03,131.21 126.08,131.23 126.12,131.25 126.16,131.28 126.2,131.32 126.23,131.36 126.26,131.4 126.27,131.45 126.28,131.51 126.28,131.56 126.27,131.61 126.26,131.66 126.23,131.7 126.2,131.75 126.16,131.78 126.12,131.81 126.08,131.84 126.03,131.85 125.98,131.86 125.92,131.86 125.87,131.85 125.82,131.84 125.78,131.81 125.73,131.78 125.7,131.75 125.67,131.7 125.64,131.66 125.63,131.61 125.62,131.56 124.64,131.56 124.64,135.65 124.92,135.93 126.47,135.93
+1.05VS_AUSB3PLL on BOTTOM (solid shape): 120.5,136.26 120.5,135.1 120.96,134.65 120.96,132.53 120.81,132.38 119.57,132.38 119.04,132.92 119.04,134.87 118.59,135.32 118.59,136.22 118.71,136.34 120.43,136.34
+1.05VS_AXCK_DCB on TOP (solid shape): outline of 460 points within 118.69,119.69 123.19,136.55
+1.05VSP on TOP (solid shape): 148.17,143.2 148.17,140.6 147.86,140.28 140.55,140.28 140.3,140.54 140.3,143.2 140.49,143.39 147.98,143.39
+1.05VSP on BOTTOM (solid shape): 145.89,145.73 145.89,144.66 146.08,144.47 147.49,144.47 147.73,144.23 147.73,141.01 147.44,140.73 140.62,140.73 140.36,140.98 140.36,144.16 140.68,144.47 142.08,144.47 142.27,144.66 142.27,145.8 142.33,145.86 145.76,145.86
+1.5VSP on BOTTOM (solid shape): 110.63,32.87 110.63,31.79 110.95,31.47 111.58,31.47 111.58,32.02 111.83,32.02 111.83,31.47 112.38,31.47 112.38,32.02 112.63,32.02 112.63,31.47 113.42,31.47 113.55,31.35 113.55,29.19 110.44,29.19 108.91,30.71 105.93,30.71 105.67,30.97 105.67,33 105.93,33.25 110.25,33.25
+1.8VGA on TOP (solid shape): 36.29,117.16 36.29,116.65 35.72,116.65 35.72,115.25 36.29,115.25 36.29,114.92 36.26,114.89 34.72,114.89 34.48,115.12 34.48,116.93 34.83,117.28 36.16,117.28
+1.8VGA on TOP (solid shape): 21.68,114.49 22.06,114.49 22.32,114.74 22.57,114.74 22.57,114.74 24.53,114.74 24.53,114.74 25.37,114.74 25.43,114.68 25.43,114.3 24.75,113.62 24.75,113.09 24.6,112.94 20,112.94 19.9,113.03 19.9,113.73 20.03,113.85 20.6,113.85 20.76,114.01 20.76,114.67 20.9,114.81 21.36,114.81
+1.8VGAP on TOP (solid shape): 39.26,115.82 41.68,115.82 41.88,115.63 41.88,114.74 41.56,114.43 38.13,114.43 37.67,114.89 36.49,114.89 36.45,114.93 36.45,115.39 36.41,115.43 35.94,115.43 35.91,115.47 35.91,115.63 35.94,115.67 36.44,115.67 36.46,115.69 36.46,116.2 36.43,116.24 35.92,116.24 35.9,116.26 35.9,116.44 35.93,116.46 36.43,116.46 36.46,116.49 36.46,117.24 36.5,117.28 37.8,117.28
+1.8VGAP on BOTTOM (solid shape): 41.88,115.95 41.88,112.44 41.58,112.15 39.84,112.15 39.68,112.31 39.68,115.96 39.89,116.17 41.65,116.17
+1.8VGS on BOTTOM (solid shape): 186.69,87.4 186.69,85.96 186.59,85.86 185.81,85.86 185.75,85.93 185.75,87.36 185.91,87.52 186.58,87.52
+1.8VS on TOP (solid shape): 214.41,96.4 214.64,96.4 214.64,95.88 215.15,95.88 215.15,96.4 215.44,96.4 215.44,95.88 215.95,95.88 215.95,96.4 216.06,96.4 216.31,96.4 216.44,96.28 216.44,94.56 215.68,93.81 214.72,93.81 213.96,94.56 213.96,96.34 214.02,96.4 214.41,96.4
+1.8VS on BOTTOM (solid shape): 185.01,87.4 185.01,86.11 184.79,85.89 184.34,85.89 184.12,86.12 184.12,87.36 184.31,87.55 184.86,87.55
+1.8VS on IN1 (solid shape): 185.86,87.13 185.86,86.78 185.32,86.24 184.18,86.24 184.12,86.31 184.12,87.2 184.24,87.32 185.67,87.32
+1.8VS on IN1 (solid shape): 215.55,95.32 215.55,93.95 215.21,93.61 214.21,93.61 213.96,93.86 213.96,94.53 214.91,95.48 215.39,95.48
+1.8VS_DAC on TOP (solid shape): 17.02,106.5 17.02,101.78 16.71,101.47 15.28,101.47 15.06,101.69 15.06,106.65 15.12,106.71 16.82,106.71
+1.8VS_DAC on IN2 (solid shape): 17,106.51 17,101.68 16.69,101.37 13.59,101.37 13.42,101.54 13.42,102.25 14.54,103.37 14.54,106.56 14.76,106.78 16.73,106.78
+1.8VS_RXVCC on TOP (solid shape): 25.52,112.56 25.52,111.64 25.25,111.38 23.63,111.38 23.55,111.47 23.55,112.55 23.66,112.66 25.42,112.66
+1.8VS_RXVCC on IN1 (solid shape): outline of 199 points within 22.78,100.76 26.29,112.58
+1.8VS_RXVDD on TOP (solid shape): 25.45,109.16 25.45,106.86 25.15,106.56 24.2,106.56 24.06,106.7 24.06,107.64 24.41,107.99 24.41,109.15 24.51,109.25 25.36,109.25
+1.8VS_RXVDD on TOP (solid shape): 22.19,112.33 22.19,111.51 21.36,110.68 20.41,110.68 20.35,110.74 20.35,111 21.11,111.76 21.11,112.33 21.17,112.39 22.13,112.39
+1.8VS_RXVDD on IN2 (solid shape): outline of 1065 points within 16.48,97.36 26.44,111.62
+1.8VSP on TOP (solid shape): 218.91,99.01 218.91,95.6 218.72,95.41 217.34,95.41 216.69,96.06 216.69,96.34 216.44,96.59 215.8,96.59 215.8,96.02 215.57,96.02 215.57,96.53 215.55,96.53 215.55,96.54 215.04,96.54 215.04,96.53 215.02,96.53 215.02,96.02 214.78,96.02 214.78,96.59 214.34,96.59 214.15,96.78 214.15,97.48 215.88,99.21 218.71,99.21
+1.8VSP on BOTTOM (solid shape): 220.37,98.34 221.28,98.34 221.45,98.17 221.45,96.85 221.4,96.8 220.19,96.8 220.17,96.77 220.14,96.74 219.02,95.62 217.25,95.62 216.9,95.96 216.9,97.9 218.02,99.02 219.69,99.02
+1.35V on TOP (solid shape): outline of 21167 points within 64.44,28.2 169.17,111.54
+1.35V on BOTTOM (solid shape): 102.44,99.64 103.25,99.64 103.6,99.99 105.61,99.99 106.33,99.27 108.8,99.27 110.3,97.77 110.3,96.87 110,96.56 98.82,96.56 98.12,97.26 98.12,99.18 98.31,99.38 100.22,99.38 100.84,99.99 102.08,99.99
+1.35V on BOTTOM (solid shape): 151.66,30.17 151.66,28.21 151.41,27.96 145.76,27.96 145.76,28.47 145.06,28.47 145.06,27.95 144.56,27.95 144.56,28.47 143.86,28.47 143.86,27.95 143.22,27.95 143.09,28.08 143.09,28.96 143.74,29.6 143.74,29.95 144.17,30.39 151.44,30.39
+1.35V_MEM_GFX on TOP (solid shape): 198.29,156.72 198.29,155.98 198.02,155.71 197.83,155.71 197.37,156.17 192.3,156.17 191.84,155.71 191.55,155.71 190.21,154.38 181.64,154.38 181.13,154.89 181.13,156.41 181.32,156.6 193.45,156.6 193.77,156.92 198.09,156.92
+1.35V_MEM_GFX on TOP (solid shape): 186.47,128.41 186.47,126.76 186.72,126.5 186.72,125.99 186.97,125.74 186.97,125.11 186.85,124.98 185.26,124.98 184.62,125.61 184.62,126.5 184.75,126.63 185.45,126.63 185.77,126.95 185.77,128.41 185.83,128.47 186.4,128.47
+1.35V_MEM_GFX on TOP (solid shape): 219.45,133.8 219.45,128.1 219.97,127.58 219.97,126.26 219.85,126.14 219.34,126.14 219.27,126.21 219.27,127.57 219,127.83 218.64,127.83 218.55,127.93 218.55,131.07 217.71,131.9 216.15,131.9 215.97,132.09 215.97,134.77 216.15,134.96 218.29,134.96
+1.35V_MEM_GFX on TOP (solid shape): 218.84,118.46 218.84,110.99 219.09,110.73 219.09,102.43 218.47,101.8 216.5,101.8 216.31,101.99 216.31,102.3 218.36,104.35 218.36,109.06 218.01,109.41 218.01,110.09 216.51,111.58 216.07,111.58 215.89,111.76 215.89,112.2 215.89,112.21 215.89,114.59 216.4,114.59 216.4,114.54 216.41,114.48 216.42,114.43 216.45,114.39 216.48,114.34 216.51,114.3 216.55,114.27 216.6,114.24 216.65,114.22 216.7,114.21 216.75,114.21 216.81,114.21 216.86,114.22 216.91,114.24 216.96,114.27 217,114.3 217.03,114.34 217.06,114.39 217.09,114.43 217.1,114.48 217.11,114.54 217.11,114.59 217.1,114.64 217.09,114.69 217.06,114.74 217.03,114.79 217,114.83 216.96,114.86 216.91,114.89 216.86,114.91 216.81,114.92 216.75,114.92 216.7,114.92 216.65,114.91 216.6,114.89 216.55,114.86 216.51,114.83 216.48,114.79 216.45,114.74 216.42,114.69 216.41,114.64 216.4,114.59 215.89,114.59 215.89,118.35 216.2,118.66 218.63,118.66
+1.35V_MEM_GFX on TOP (solid shape): 161.45,158.63 161.45,156.98 161.89,156.54 171.35,156.54 171.67,156.86 174.91,156.86 175.86,157.81 177.19,157.81 177.38,157.62 177.38,156.98 177.26,156.86 175.86,156.86 175.13,156.12 171.93,156.12 171.71,155.9 170.84,155.9 169.26,154.32 160.49,154.32 159.86,154.95 158.84,154.95 157.71,153.82 157.71,151.71 157.78,151.65 158.21,151.65 158.47,151.39 158.47,148.33 158.36,148.23 157.7,148.23 156.69,149.24 156.69,154.39 156.75,154.49 156.87,154.46 157.36,154.44 157.4,154.93 157.39,155.04 157.48,155.1 157.85,155.1 159.54,156.79 159.54,158.76 159.64,158.86 161.22,158.86
+1.35V_MEM_GFX on BOTTOM (solid shape): 214.66,151.95 214.66,151.48 214.14,151.48 214.14,151.04 214.66,151.04 214.66,150.45 214.33,150.12 212.04,150.12 211.77,150.39 211.77,151.68 212.19,152.09 214.51,152.09
+1.35V_MEM_GFX on BOTTOM (solid shape): 218.69,113.79 218.69,104.38 218.27,103.97 216.33,103.97 216.09,104.21 216.09,111.56 215.9,111.75 215.9,113.9 215.96,113.96 216.45,113.96 216.46,113.97 218.51,113.97
+1.35V_MEM_GFX on BOTTOM (solid shape): 218.84,139.32 218.84,126.29 218.63,126.08 217.09,126.08 216.55,126.63 216.55,131.69 216.01,132.22 216.01,134.11 217.82,135.92 218.15,136.25 218.15,139.38 218.78,139.38
+1.35V_MEM_GFX on BOTTOM (solid shape): 184.94,156.54 195.93,156.54 196.12,156.35 196.12,154.63 195.8,154.32 187.86,154.32 186.66,155.52 186.37,155.52 186.12,155.78 184.43,155.78 183.7,156.51 183.7,156.53 183.68,156.53 183.54,156.66 182.21,156.66 182.02,156.86 182.02,157.36 182.27,157.62 183.86,157.62
+1.35V_MEM_GFX on BOTTOM (solid shape): 177.38,157.62 177.38,157.05 177.19,156.86 175.8,156.86 175.67,156.73 175.67,156.41 173.57,154.32 167.22,154.32 165.69,155.84 161.51,155.84 161.45,155.9 161.45,156.6 161.51,156.66 162.33,156.66 162.37,156.63 171.67,156.63 171.7,156.66 172.24,156.66 172.5,156.92 174.21,156.92 174.97,157.68 177.32,157.68
+1.35V_MEM_GFX on IN1 (solid shape): outline of 23553 points within 162.02,98.18 218.13,155.78
+1.35VGPUP on BOTTOM (solid shape): 184.88,167.33 184.88,166.38 185.7,165.55 189.96,165.55 190.21,165.3 190.21,162.25 190.08,162.13 188.93,162.13 188.93,161.57 188.49,161.57 188.49,162.12 187.74,162.12 187.74,161.57 187.29,161.57 187.29,162.12 183.61,162.12 183.61,161.57 183.16,161.57 183.16,162.12 182.41,162.12 182.41,161.57 181.95,161.57 181.95,162.13 174.67,162.13 174.29,162.51 174.29,166.19 174.67,166.57 179.92,166.57 181.45,168.09 184.12,168.09
+1.35VP on TOP (solid shape): 151.67,27.76 151.67,25.86 151.58,25.77 147.58,25.77 147.29,26.06 147.29,27.76 147.54,28.01 151.41,28.01
+1.35VP on BOTTOM (solid shape): 156.18,26.11 156.18,25.6 156.43,25.35 157.32,25.35 157.38,25.28 157.38,25.16 157.33,25.11 155.97,25.11 155.74,25.34 155.74,26.05 155.86,26.17 156.11,26.17
+1.35VP on BOTTOM (solid shape): 144.43,27.82 144.46,27.82 144.46,27.82 145.16,27.82 145.16,27.82 145.18,27.82 145.18,28.33 145.62,28.33 145.62,27.77 152.82,27.77 153.01,27.58 153.01,26.06 152.56,25.61 150.28,25.61 149.45,24.79 149.45,13.55 148.94,13.04 143.67,13.04 143.55,13.17 143.55,25.85 143.09,26.31 143.09,27.63 143.23,27.77 143.99,27.77 143.99,28.33 144.43,28.33
+1.35VP on IN2 (solid shape): 148.81,25.66 148.81,24.97 148.68,24.84 146.84,24.84 146.65,25.03 146.65,25.41 146.97,25.73 148.75,25.73
+1.35VP on IN2 (solid shape): 156.24,26.05 156.24,25.28 155.92,24.97 154.52,24.97 154.27,25.22 154.27,25.66 154.4,25.79 155.54,25.79 155.92,26.17 156.11,26.17
+1.35VS_VGA on BOTTOM (solid shape): 216.78,151.13 216.78,149.86 216.56,149.64 215.24,149.64 214.82,150.05 214.82,151.17 214.27,151.17 214.27,151.35 214.82,151.35 214.82,151.86 214.92,151.96 215.95,151.96
+1.35VS_VGA on BOTTOM (solid shape): 181.81,161.44 181.83,161.44 182.53,161.44 182.53,161.94 183.03,161.94 183.03,161.44 183.73,161.44 183.73,161.94 187.16,161.94 187.16,161.44 187.87,161.44 187.87,161.94 188.36,161.94 188.36,161.44 189.07,161.44 189.07,161.94 190.08,161.94 190.47,161.55 190.47,159.97 190.21,159.71 180.69,159.71 180.24,160.16 180.24,161.7 180.5,161.96 181.81,161.96
+1.35VS_VGA on IN2 (solid shape): 198.71,159.04 208.62,159.04 216.95,150.72 216.95,149.97 216.22,149.24 215.2,149.24 207.91,156.54 197.58,156.54 193.48,160.64 189.64,160.64 188.97,159.97 180.88,159.97 180.56,160.28 180.56,162.06 181.21,162.71 195.04,162.71
+1.35VS_VGA on VCC: 193.43,101.17 189.51,105.08 189.51,108.89 186.21,112.19 186.21,124.77 185.05,125.93 183.97,125.93 182.82,127.07 173.11,127.07 162.02,138.16 162.02,154.34 167.58,159.9 179.78,159.9 181.87,162 196.14,162 217.26,140.88 217.26,106.22 212.2,101.17
+3V_WLAN on TOP (solid shape): 107.02,147.87 107.02,146.54 106.98,146.51 105.27,146.51 105.15,146.63 105.15,147.98 105.25,148.09 106.8,148.09
