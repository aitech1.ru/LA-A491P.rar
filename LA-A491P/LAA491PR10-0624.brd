# Allegro board LAA491PR10-0624.brd (continued)
## Nets (continued)
MDI0+: TL2.12 UL1.1
MDI0-: TL2.11 UL1.2
MDI1+: TL2.8 UL1.4
MDI1-: TL2.7 UL1.5
MDI2+: TL2.6 UL1.6
MDI2-: TL2.5 UL1.7
MDI3+: TL2.2 UL1.9
MDI3-: TL2.1 UL1.10
MDO0+: JLAN.1 TL2.13
MDO0-: JLAN.2 TL2.14
MDO1+: JLAN.3 TL2.17
MDO1-: JLAN.6 TL2.18
MDO2+: JLAN.4 TL2.19
MDO2-: JLAN.5 TL2.20
MDO3+: JLAN.7 TL2.23
MDO3-: JLAN.8 TL2.24
ME_EN: RC8.1 RE326.1 UE1.99
ME_SUS_PWR_ACK: RC27.2 RC42.1 UE1.34
ME_SUS_PWR_ACK_R: RC35.1 RC42.2 UC1.AV4
MECH#1: T82.1(TP-1) UV1.A39
MECH#2: T83.1(TP-1) UV1.AW1
MECH#3: T84.1(TP-1) UV1.AW39
MEM_SMBCLK: QC1.6 RP40.1 UC1.AP2
MEM_SMBDATA: QC1.3 RP40.2 UC1.AH1
MIC1-L: CA74.1 UA1.19
MIC_CLK: CA22.1 JLVDS.30 LA1.2
MIC_CLK_C: LA1.1 UA1.3
MIC_DATA: JLVDS.32 UA1.2
MIC_IN: LA7.2 QA6.3 RA53.1 UA1.18
MIC_IN_R: CA38.1 DA12.3 JHP.4 LA7.1
MIIC_SCL: RX169.2 RX171.1 UX4.48
MIIC_SDA: RX168.2 RX170.1 UX4.47
MS_BS: JREAD.15 UR1.22
MS_CLK_SD_WP: CR5.1 JREAD.5 JREAD.22 RR3.2
MS_CLK_SD_WP_R: RR3.1 UR1.8
MS_D0: JREAD.12 UR1.16
MS_D1_SD_D3: JREAD.3 JREAD.13 UR1.20
MS_D2_SD_CLK: CR6.1 JREAD.10 JREAD.14 RR2.2
MS_D2_SD_CLK_R: RR2.1 UR1.15
MS_D3: JREAD.7 UR1.12
MS_INS#: CR10.1 JREAD.8 UR1.9
O-USR: PR502.1 PR506.2 PU501.9
OCP_CPU: PR501.1 PR503.2 PU501.12
ODD_DA#: CS17.1 JODD.11 RP54.1 UC1.T3
ODD_DETECT#: JODD.8 RP37.1 UC1.V6
ODD_EN: CS16.1 QS2.3 QS3.1 RS6.1
ODD_EN#: QS3.2 UC1.Y1
ON/OFFBTN#: CE20.1 JPWR.3 RE49.1 SW1.3 SW1.4 SW2.3 SW2.4 UE1.114
PACIN#: QV14.5 QV14.6 RV74.2
PANEL_BKLEN: UC1.A9 UE1.76
PBTN_OUT#: RC49.1 UC1.AL7 UE1.106
PC_BEEP: DA8.1 RA19.1 RA79.2
PCH_AUDIO_EN: RC116.1 UC1.P1
PCH_AZ_BITCLK: R2359.2 UC1.AW8
PCH_AZ_CODEC_BITCLK: CC5.1 R2355.1 R2359.1 UA1.6
PCH_AZ_CODEC_RST#: R2358.1 RA6.1 UA1.11
PCH_AZ_CODEC_SDIN0: RA130.1 UC1.AY10
PCH_AZ_CODEC_SDOUT: R2356.1 UA1.5
PCH_AZ_CODEC_SYNC: R2357.1 UA1.10
PCH_AZ_RST#: R2358.2 UC1.AU8
PCH_AZ_SDOUT: R2356.2 RC3.2 RC8.2 UC1.AU11
PCH_AZ_SYNC: R2357.2 UC1.AV11
PCH_BATLOW#: RC31.2 UC1.AN4
PCH_DPWROK: RC33.1 RE37.1 UC1.AV5
PCH_GPIO9: RC125.2 UC1.AM3
PCH_GPIO12: T182.1(TP-1) UC1.AM7
PCH_GPIO14: T126.1(TP-1) UC1.AH4
PCH_GPIO25: T127.1(TP-1) UC1.AM4
PCH_GPIO35: RP37.2 UC1.U1
PCH_GPIO37: RP37.3 UC1.AC1
PCH_GPIO44: RC104.1 UC1.AK4
PCH_GPIO46: RC124.2 UC1.AG3
PCH_GPIO47: T174.1(TP-1) UC1.AB6
PCH_GPIO48: T124.1(TP-1) UC1.U4
PCH_GPIO49: T125.1(TP-1) UC1.Y3
PCH_GPIO66: RC118.2 RC122.1 UC1.D3
PCH_GPIO83: T177.1(TP-1) UC1.R6
PCH_GPIO84: T176.1(TP-1) UC1.L6
PCH_GPIO85: T175.1(TP-1) UC1.N6
PCH_GPIO89: T178.1(TP-1) UC1.N7
PCH_GPIO90: T179.1(TP-1) UC1.K2
PCH_GPIO93: T180.1(TP-1) UC1.J2
PCH_GPIO94: T181.1(TP-1) UC1.G1
PCH_HOT#: R2330.2 RE7.1 UC1.AU4
PCH_INTVRMEN: RC1.2 RC2.1 UC1.AV7
PCH_JTAG_JTAGX: RC59.1 RC62.2 RC130.1 UC1.AE63
PCH_JTAG_RST#: R2341.2 RC57.2 UC1.AU62
PCH_JTAG_TCK: RC65.2 RC135.1 RP46.4 UC1.AE62
PCH_JTAG_TDI: RC44.1 RP48.8 UC1.AD61
PCH_JTAG_TDO: RC43.1 RC63.2 RP48.7 UC1.AE61
PCH_JTAG_TMS: RC46.1 RP48.6 UC1.AD62
PCH_OPI_COMP: RC101.1 UC1.AW15
PCH_PCIE_RCOMP: RC91.2 UC1.A27
PCH_PLTRST#: CC33.1 UC1.AG7 UC3.1 UC3.2
PCH_PWR_EN: R416.1 RE36.1
PCH_PWROK: CC34.1 CE31.1 RE18.1 RP50.2 RP50.3 UE1.32
PCH_PWROK_R: RP50.7 UC1.AY7
PCH_RSMRST#_R: RC33.2 RC41.2 UC1.AW6
PCH_RTCRST#: CC4.2 CMOS1.2 RC6.2 UC1.AU7
PCH_RTCX1: CC1.2 RC4.1 RG3.2 UC1.AW5 YC1.1
PCH_RTCX1_R: RG3.1 UG1.9
PCH_RTCX2: CC2.2 RC4.2 UC1.AY5 YC1.2
PCH_SMB_ALERT#: R2329.2 UC1.AN2
PCH_SPI_CLK: R2333.2 UC1.AA3
PCH_SPI_CLK_R: C2326.1 R2333.1 U2302.6
PCH_SPI_CS0#: U2302.1 UC1.Y7
PCH_SPI_HOLD1#: RP39.4 U2302.7
PCH_SPI_HOLD#: R2335.2 RP39.5 UC1.AF1
PCH_SPI_MISO: RP39.7 UC1.AA4
PCH_SPI_MISO_1: RP39.2 U2302.2
PCH_SPI_MOSI: RP39.8 UC1.AA2
PCH_SPI_MOSI_1: RP39.1 U2302.5
PCH_SPI_WP1#: RP39.3 U2302.3
PCH_SPI_WP#: R2334.2 RP39.6 UC1.Y6
PCH_X1_R: RG6.1 UG1.5
PCIE_B+: PC1301.1 PJP1301.1 PU1300.8 PU1300.9 PU1300.10
PCIE_CRX_C_GTX_N0: CV44.2 UV1.Y32
PCIE_CRX_C_GTX_N1: CV46.2 UV1.W32
PCIE_CRX_C_GTX_N2: CV48.2 UV1.U32
PCIE_CRX_C_GTX_N3: CV50.2 UV1.U29
PCIE_CRX_C_GTX_P0: CV43.2 UV1.Y33
PCIE_CRX_C_GTX_P1: CV45.2 UV1.W33
PCIE_CRX_C_GTX_P2: CV47.2 UV1.U33
PCIE_CRX_C_GTX_P3: CV49.2 UV1.U30
PCIE_PRX_LANTX_N3: CL31.1 UC1.G11
PCIE_PRX_LANTX_N3_C: CL31.2 UL1.18
PCIE_PRX_LANTX_P3: CL30.1 UC1.F11
PCIE_PRX_LANTX_P3_C: CL30.2 UL1.17
PCIE_PRX_WLANTX_N4: JMINI.23 UC1.F13
PCIE_PRX_WLANTX_P4: JMINI.25 UC1.G13
PCIE_PTX_LANRX_N3: CC32.1 UL1.14
PCIE_PTX_LANRX_N3_C: CC32.2 UC1.C29
PCIE_PTX_LANRX_P3: CC40.1 UL1.13
PCIE_PTX_LANRX_P3_C: CC40.2 UC1.B30
PCIE_PTX_WLANRX_N4: CM49.1 UC1.B29
PCIE_PTX_WLANRX_N4_C: CM49.2 JMINI.31
PCIE_PTX_WLANRX_P4: CM44.1 UC1.A29
PCIE_PTX_WLANRX_P4_C: CM44.2 JMINI.33
PCIE_WAKE#: RC97.2 RL34.2 UE1.29 UL1.21
PCIE_WAKE#_R: RC34.2 RC97.1 UC1.AJ5
PCSCL: RP1.8 U4.47
PCSDA: RP1.7 U4.48
PECI_EC: RE43.2 UC1.N62
PECI_KB9012: RE43.1 UE1.118
PEG_CLKREQ#: QV28.1 RP42.6 UC1.U5
PEG_CRX_GTX_N0: CV44.1 UC1.F10
PEG_CRX_GTX_N1: CV46.1 UC1.F8
PEG_CRX_GTX_N2: CV48.1 UC1.H10
PEG_CRX_GTX_N3: CV50.1 UC1.E6
PEG_CRX_GTX_P0: CV43.1 UC1.E10
PEG_CRX_GTX_P1: CV45.1 UC1.E8
PEG_CRX_GTX_P2: CV47.1 UC1.G10
PEG_CRX_GTX_P3: CV49.1 UC1.F6
PEG_CTX_GRX_C_N0: CC18.1 UC1.C23
PEG_CTX_GRX_C_N1: CC20.1 UC1.B23
PEG_CTX_GRX_C_N2: CC22.1 UC1.B21
PEG_CTX_GRX_C_N3: CC24.1 UC1.B22
PEG_CTX_GRX_C_P0: CC19.1 UC1.C22
PEG_CTX_GRX_C_P1: CC21.1 UC1.A23
PEG_CTX_GRX_C_P2: CC23.1 UC1.C21
PEG_CTX_GRX_C_P3: CC25.1 UC1.A21
PEG_CTX_GRX_N0: CC18.2 UV1.Y37
PEG_CTX_GRX_N1: CC20.2 UV1.W36
PEG_CTX_GRX_N2: CC22.2 UV1.V37
PEG_CTX_GRX_N3: CC24.2 UV1.U36
PEG_CTX_GRX_P0: CC19.2 UV1.AA38
PEG_CTX_GRX_P1: CC21.2 UV1.Y35
PEG_CTX_GRX_P2: CC23.2 UV1.W38
PEG_CTX_GRX_P3: CC25.2 UV1.V35
PLT_RST#: CC30.1 CE36.1 JMINI.22 R159.1 RC51.1 UC3.4 UE1.13 UL1.19 UV13.2
PM_APWROK_R: RP50.6 UC1.AB5
PROC_OPI_RCOMP: RC134.1 UC1.AY15
PROJECT_ID: RC112.2 RC113.1 UC1.L5
PS_0: CV335.1 RV201.1 RV243.2 UV1.AM34
PS_1: CV329.1 RV237.2 RV238.1 UV1.AD31
PS_2: CV331.1 RV239.2 RV240.1 UV1.AG31
PS_3: CV333.1 RV241.2 RV242.1 UV1.AD33
PS_ID: PR3.1 PR4.2 UE1.16
PSID: PJPDC.1 PL2.1
PSID-1: PQ5.2 PR6.1 PR9.2
PSID-2: PQ5.1 PQ6.2 PR8.2
PSID-3: PQ6.3 PR4.1
PWM1: PU501.6 PU502.8
PWR_PWM_LED#: RD14.1 UE1.92
PWR_SRC_ON: CX4.2 QX2.3 RX2.2 RX3.1
PXS_PWREN: PR601.2 PR803.1 PR1103.1 PR1206.2 PR1300.1 QV24.2 QV25.2 RP54.4 RV105.2 UC1.P4
PXS_PWREN#: QV25.1 RV109.2
RASA0#: UV1.K23 UV4.G3 UV5.L3
RASA1#: UV1.K19 UV3.L3 UV6.G3
RASB0#: UV1.T10 UV7.L3 UV8.G3
RASB1#: UV1.Y10 UV9.L3 UV10.G3
RED_CRT: C2.1 L6.1 R31.1 U4.6
RED_CRT_L: C5.1 DE3.3 JCRT1.1 L6.2
REGN: PC709.1 PD701.2 PR707.1 PR713.1 PU701.16
RF_+1.2VSP: PR1105.1 PU1100.5
RING2: LA10.2 RA1109.1 UA1.17
RING2_R: CA40.1 DA12.2 JHP.3 LA10.1
RREF: RR1.1 UR1.1
RSVD_AL1: T136.1(TP-1) UC1.AL1
RSVD_AM11: T137.1(TP-1) UC1.AM11
RSVD_AP7: T139.1(TP-1) UC1.AP7
RSVD_AT2: T128.1(TP-1) UC1.AT2
RSVD_AU10: T141.1(TP-1) UC1.AU10
RSVD_AU15: T142.1(TP-1) UC1.AU15
RSVD_AU44: T132.1(TP-1) UC1.AU44
RSVD_AV44: T134.1(TP-1) UC1.AV44
RSVD_AW14: T144.1(TP-1) UC1.AW14
RSVD_AY14: T145.1(TP-1) UC1.AY14
RSVD_D15: T135.1(TP-1) UC1.D15
RSVD_F22: T138.1(TP-1) UC1.F22
RSVD_H22: T140.1(TP-1) UC1.H22
RSVD_J21: T143.1(TP-1) UC1.J21
RSVD_N23: T129.1(TP-1) UC1.N23
RSVD_R23: T130.1(TP-1) UC1.R23
RSVD_T23: T131.1(TP-1) UC1.T23
RSVD_U10: T133.1(TP-1) UC1.U10
RTC_VOUT: CG6.1 RG2.2 UG1.14
RUNPWROK: CC29.1 UC4.1 UC4.4 UC4.10 UC4.13 UE1.36
SATA_ACT#: RD15.1 UC1.U3
SATA_IREF: RC126.1 UC1.A12
SATA_PRX_DTX_N0: CS109.1 JHDD.5
SATA_PRX_DTX_N0_C: CS109.2 UC1.J5
SATA_PRX_DTX_N1: CS14.1 JODD.5
SATA_PRX_DTX_N1_C: CS14.2 UC1.J8
SATA_PRX_DTX_P0: CS108.1 JHDD.6
SATA_PRX_DTX_P0_C: CS108.2 UC1.H5
SATA_PRX_DTX_P1: CS15.1 JODD.6
SATA_PRX_DTX_P1_C: CS15.2 UC1.H8
SATA_PTX_DRX_N0: CS106.1 JHDD.3
SATA_PTX_DRX_N0_C: CS106.2 UC1.B15
SATA_PTX_DRX_N1: CS9.1 JODD.3
SATA_PTX_DRX_N1_C: CS9.2 UC1.A17
SATA_PTX_DRX_P0: CS105.1 JHDD.2
SATA_PTX_DRX_P0_C: CS105.2 UC1.A15
SATA_PTX_DRX_P1: CS8.1 JODD.2
SATA_PTX_DRX_P1_C: CS8.2 UC1.B17
SATA_RCOMP: RC131.1 UC1.C12
SD_CD#: CR9.1 JREAD.20 UR1.13
SD_CMD: CR11.1 JREAD.6 UR1.18
SD_D0: JREAD.18 UR1.11
SD_D1: JREAD.19 UR1.10
SD_D2: JREAD.1 UR1.21
SERIRQ: RC102.2 UC1.T4 UE1.3
SIO_EXT_SCI#: RC98.1 UC1.N5
SIO_SLP_S0#: UC1.AF3 UE1.89
SIO_SLP_S3#: CE27.1 UC1.AT4 UE1.6
SIO_SLP_S4#: T104.1(TP-1) UC1.AJ6 UE1.84
SIO_SLP_S5#: CE28.1 T103.1(TP-1) UC1.AP5 UE1.14
SKIP#: PR535.1 PU501.7
SKIP#1: PR535.2 PU502.1
SLATE_MODE_R: RC110.1 UC1.AL4
SLEWA_CPU: PR513.2 PR514.1 PU501.15
SM_RCOMP0: RC68.1 UC1.AU60
SM_RCOMP1: RC69.1 UC1.AV60
SM_RCOMP2: RC70.1 UC1.AU61
SML0CLK: RP49.1 UC1.AN1
SML0DATA: RP49.2 UC1.AK1
SML1_SMBCLK: QH1.1 RP40.3 UC1.AU3
SML1_SMBDATA: QH1.4 RP40.4 UC1.AH3
SNB_1.05V: PC301.1 PR302.2
SNB_VDDCI: PC1212.1 PR1207.2
SNUB_PCIE: PC1304.1 PR1303.2
SPK_L1-_CONN: CA30.1 JSPK.3 LA5.2
SPK_L2+_CONN: CA29.1 JSPK.4 LA6.2
SPK_R1-_CONN: CA32.1 JSPK.1 LA3.2
SPK_R2+_CONN: CA31.1 JSPK.2 LA4.2
SRTCRST#: CC3.2 ME1.2 RC5.2 UC1.AV6
SUS_STAT#/LPCPD#: RC29.2 UC1.AG4
SUSACK#: RC28.2 RC35.2 RC37.1 UE1.97
SUSACK#_R: RC37.2 UC1.AK2
SUSCLK: T102.1(TP-1) UC1.AE6
SUSP: Q8.1 Q2307.2 Q2308.2 R10.2
SUSP#: PR300.2 PR401.2 Q8.2 R16.1 R2313.1 R2318.1 UE1.116
SW_1.35V: PC200.2 PC207.1 PL200.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PU200.16
SW_+1.2VSP: PC1103.2 PL1101.1 PQ1100.1 PQ1100.2 PQ1100.3 PQ1101.5 PR1104.1 PU1100.8
SW_CPU2: PC520.1 PL502.1 PU502.4
SW_VGA_CORE: PC807.2 PC815.1 PL802.1 PQ800.1 PQ800.2 PQ800.3 PQ801.5 PQ802.5 PQ803.1 PQ803.2 PQ803.3 PR829.1 PU800.16
SYS_PWROK: CC31.1 CE32.1 RC52.1 RP50.1 UE1.86
SYS_PWROK_R: RP50.8 UC1.AG2
SYS_PWROK_XDP: CC16.1 JXDP1.47 RC52.2 RC64.1
SYS_RESET#: RC26.2 UC1.AC3
SYSON: CE26.1 PR201.1 UE1.95
TDI_IREF: RC133.2 UC1.B12
TDI_XDP: JXDP1.56 RC44.2 RC45.1
TDI_XDP_R: RC45.2 RC63.1 UC4.5
TDO_XDP: JXDP1.52 RC43.2 RC62.1 RP44.4 UC4.2
TESTEN: RV133.2 UV1.AD28
THERM_CPU: PC509.1 PH502.2 PR512.2 PU501.14
THM_ALERT#: RV96.1 UV1.AG30 UV14.6
TL_BKOFF#: DX1.2 RX50.2 UX2.4
TL_BKOFF#_R: RX33.1 UX2.2 UX4.44
TL_ENVDD: RX7.2 RX51.2 UX4.20
TL_INVT_PWM: JLVDS.36 RX26.1 RX49.2 UX4.19
TMS_XDP: JXDP1.58 RC46.2 UC4.9
TON_1.35V: PR208.2 PU200.9
TOUCH_PANEL_INTR#: RP43.7 UC1.P3
TOUCH_RST: RX1.1 UE1.38
TOUCH_RST_N_GYRO_INT1: RC76.2 UC1.L1
TOUCH_RST_R: JTOUCH.6 RX1.2 RX24.2
TOUCHPAD_INTR#: RC74.2 UC1.U7
TP_CLK: JTP.2 RE9.2 UE1.87
TP_DATA: JTP.3 RE10.2 UE1.88
TP_DC_TEST_B2: T167.1(TP-1) UC1.B2
TRIP_+1.2VSP: PR1102.2 PU1100.2
TRST#_XDP: JXDP1.54 UC4.12
TS_FDO: RV235.2 RV236.1 UV1.AK32
UG_3V: PQ101.4 PU100.10
UG_5V: PQ103.4 PU100.16
UG_+1.2VSP: PQ1100.4 PU1100.9
UG_VGA_CORE: PQ800.4 PQ803.4 PU800.15
USB3RN1_JUSB2: LI4.1 UC1.G20
USB3RN1_JUSB2_R: DI4.1 DI4.10 JUSB2.5 LI4.2
USB3RN2_JUSB1: LI1.1 UC1.E18
USB3RN2_JUSB1_R: DI1.1 DI1.10 JUSB1.5 LI1.2
USB3RP1_JUSB2: LI4.4 UC1.H20
USB3RP1_JUSB2_R: DI4.2 DI4.9 JUSB2.6 LI4.3
USB3RP2_JUSB1: LI1.4 UC1.F18
USB3RP2_JUSB1_R: DI1.2 DI1.9 JUSB1.6 LI1.3
USB3TN1_JUSB2: CI10.2 UC1.C33
USB3TN1_JUSB2_C: CI10.1 LI6.1
USB3TN1_JUSB2_R: DI4.4 DI4.7 JUSB2.8 LI6.2
USB3TN2_JUSB1: CI3.2 UC1.B33
USB3TN2_JUSB1_C: CI3.1 LI3.1
USB3TN2_JUSB1_R: DI1.4 DI1.7 JUSB1.8 LI3.2
USB3TP1_JUSB2: CI11.2 UC1.B34
USB3TP1_JUSB2_C: CI11.1 LI6.4
USB3TP1_JUSB2_R: DI4.5 DI4.6 JUSB2.9 LI6.3
USB3TP2_JUSB1: CI4.2 UC1.A33
USB3TP2_JUSB1_C: CI4.1 LI3.4
USB3TP2_JUSB1_R: DI1.5 DI1.6 JUSB1.9 LI3.3
USB20_CAM_N7: LX6.1 RX21.1 UC1.AR13
USB20_CAM_N7_R: JLVDS.28 LX6.2 RX21.2
USB20_CAM_P7: LX6.4 RX22.1 UC1.AP13
USB20_CAM_P7_R: JLVDS.27 LX6.3 RX22.2
USB20_CR_N6: LR2.1 UC1.AP11
USB20_CR_N6_R: LR2.2 UR1.2
USB20_CR_P6: LR2.4 UC1.AN11
USB20_CR_P6_R: LR2.3 UR1.3
USB20_JUSB1_N1: LI2.1 UC1.AR7
USB20_JUSB1_N1_R: DI2.2 JUSB1.2 LI2.2
USB20_JUSB1_P1: LI2.4 UC1.AT7
USB20_JUSB1_P1_R: DI2.3 JUSB1.3 LI2.3
USB20_JUSB2_N0: LI5.1 UC1.AN8
USB20_JUSB2_N0_R: DI5.2 JUSB2.2 LI5.2
USB20_JUSB2_P0: LI5.4 UC1.AM8
USB20_JUSB2_P0_R: DI5.3 JUSB2.3 LI5.3
USB20_JUSB3_N2: LI7.1 UC1.AR8
USB20_JUSB3_N2_R: DI7.2 JUSB3.2 LI7.2
USB20_JUSB3_P2: LI7.4 UC1.AP8
USB20_JUSB3_P2_R: DI7.3 JUSB3.3 LI7.3
USB20_MINI1_N4: JMINI.36 UC1.AM15
USB20_MINI1_P4: JMINI.38 UC1.AL15
USB20_TOUCH_N5: JTOUCH.2 UC1.AM13
USB20_TOUCH_P5: JTOUCH.3 UC1.AN13
USB20_USBDB_N3: LI10.1 UC1.AR10
USB20_USBDB_N3_R: JDB.5 LI10.2
USB20_USBDB_P3: LI10.4 UC1.AT10
USB20_USBDB_P3_R: JDB.4 LI10.3
USB_EN#: CI13.1 CI16.1 CI25.1 CI26.1 UE1.26 UI2.4 UI3.4 UI4.4 UI5.4
USB_OC0#: CI15.1 CI17.1 RP55.1 UC1.AL3 UI2.5 UI3.5
USB_OC1#: CI24.1 CI32.1 RP55.2 UC1.AT1 UI4.5 UI5.5
USB_OC2#: RP55.3 UC1.AH2
USB_OC3#: RP55.4 UC1.AV3
USBRBIAS: RC90.1 UC1.AJ10 UC1.AJ11
VCIN0_PH: PH1.1 PR24.1 UE1.109
VCIN1_PH: PC13.2 PR23.1 PR26.2 PR27.2 UE1.102
VCOUT0_PH#: PC100.1 PR100.2 PR101.2 PR102.2 UE1.104
VCOUT1_PH: PR30.1 RE47.2 UE1.103 UE2.2
VGA_CLKREQ#_R: QV28.3 RV199.2 UV1.AN13
VGA_SMB_CK2: QV15.1 RV90.2 RV252.1 UV14.8
VGA_SMB_CK2_R: RV252.2 UV1.AJ23
VGA_SMB_DA2: QV15.4 RV91.2 RV251.1 UV14.7
VGA_SMB_DA2_R: RV251.2 UV1.AH23
VGA_X1_R: RG4.1 UG1.12
VGADDCCLK: R22.1 U4.27
VGADDCSDA: R40.1 U4.25
VL: PC106.1 PU100.13
VR12.5_VR_ON_R: R250.2 UC1.F60
VR_ENABLE: PC522.1 PR522.1 PU501.8
VR_HOT#: PC506.2 PR533.1 PU501.30 RE44.1
VR_ON: C96.1 CE34.1 DE1.3 PR522.2 R250.1 RE1.2 RE12.2
VR_ON_EC: RE12.1 UE1.121
VR_READY_R: R251.2 UC1.C59
VR_SVID_ALRT#: PR528.2 PU501.32 R252.2 R254.2
VR_SVID_CLK: PR526.2 PU501.31 R248.1
VR_SVID_DAT: PR530.2 PU501.1 R257.2
VRAM_ID0: RV67.2 RV68.2 UV1.AU1
VRAM_ID1: RV69.2 RV70.2 UV1.AU3
VRAM_ID2: RV71.2 UV1.AW3
VREF_CPU: PC507.1 PH502.1 PR502.2 PR504.2 PR507.2 PR514.2 PR531.1 PU501.27
VREFC1: CV388.2 CV397.1 RV29.1 RV37.2 UV4.J14
VREFC2: CV328.2 CV399.1 RV183.2 RV184.1 UV5.J14
VREFC3: CV349.1 CV350.2 RV193.2 RV194.1 UV3.J14
VREFC4: CV353.1 CV354.2 RV39.1 RV197.2 UV6.J14
VREFC5: CV21.2 CV22.1 RV5.1 RV6.2 UV8.J14
VREFC6: CV27.1 CV28.2 RV11.1 RV12.2 UV7.J14
VREFC7: CV33.1 CV34.2 RV17.1 RV19.2 UV9.J14
VREFC8: CV39.1 CV40.2 RV24.1 RV27.2 UV10.J14
VREFD1_1: CV387.1 CV393.2 RV28.2 RV34.1 UV4.A10
VREFD1_2: CV394.2 CV395.1 RV35.2 RV36.1 UV4.U10
VREFD2_1: CV396.2 CV398.1 RV38.2 RV181.1 UV5.A10
VREFD2_2: CV330.2 CV400.1 RV185.2 RV186.1 UV5.U10
VREFD3_1: CV389.2 CV390.1 RV32.2 RV33.1 UV3.A10
VREFD3_2: CV332.1 CV401.2 RV191.2 RV192.1 UV3.U10
VREFD4_1: CV351.1 CV352.2 RV195.2 RV196.1 UV6.A10
VREFD4_2: CV355.1 CV356.2 RV40.2 RV41.1 UV6.U10
VREFD5_1: CV13.1 CV18.2 RV1.2 RV2.1 UV8.A10
VREFD5_2: CV19.2 CV20.1 RV3.2 RV4.1 UV8.U10
VREFD6_1: CV23.1 CV24.2 RV7.1 RV8.2 UV7.A10
VREFD6_2: CV25.1 CV26.2 RV9.1 RV10.2 UV7.U10
VREFD7_1: CV29.1 CV30.2 RV13.1 RV14.2 UV9.A10
VREFD7_2: CV31.1 CV32.2 RV15.1 RV16.2 UV9.U10
VREFD8_1: CV35.1 CV36.2 RV20.1 RV21.2 UV10.A10
VREFD8_2: CV37.1 CV38.2 RV22.1 RV23.2 UV10.U10
VSYNC_BUF: R6.1 U4.1
VSYNC_BUF_L: R4.1 U2.4
VTTREF_1.35V: PC210.1 PU200.4
WCKA0_0: UV1.A32 UV4.D4 UV5.P4
WCKA0_1: UV1.D23 UV4.P4 UV5.D4
WCKA0B_0: UV1.C32 UV4.D5 UV5.P5
WCKA0B_1: UV1.E22 UV4.P5 UV5.D5
WCKA1_0: UV1.C14 UV3.P4 UV6.D4
WCKA1_1: UV1.E10 UV3.D4 UV6.P4
WCKA1B_0: UV1.A14 UV3.P5 UV6.D5
WCKA1B_1: UV1.D9 UV3.D5 UV6.P5
WCKB0_0: UV1.H3 UV7.P4 UV8.D4
WCKB0_1: UV1.T3 UV7.D4 UV8.P4
WCKB0B_0: UV1.H1 UV7.P5 UV8.D5
WCKB0B_1: UV1.T5 UV7.D5 UV8.P5
WCKB1_0: UV1.AE4 UV9.P4 UV10.D4
WCKB1_1: UV1.AK6 UV9.D4 UV10.P4
WCKB1B_0: UV1.AF5 UV9.P5 UV10.D5
WCKB1B_1: UV1.AK5 UV9.D5 UV10.P5
WEA0#: UV1.K26 UV4.L12 UV5.G12
WEA1#: UV1.L15 UV3.G12 UV6.L12
WEB0#: UV1.N10 UV7.G12 UV8.L12
WEB1#: UV1.AB11 UV9.G12 UV10.L12
WL_BT_LED: QD20.2 RD50.1 UE1.1
WL_BT_LED#: QD20.1 RD18.1 RD51.2
WL_BT_LED#_EC: QD18.1 QD19.1 RD46.2 RD49.2 RD51.1 RD52.1 UD1.4 UE1.64
WL_BT_LED#_EC2: RD48.2 UE1.74
WL_LED#: JMINI.44 QD18.3 RD45.2 RD48.1 UD1.1
WL_OFF#: QM30.3 RP54.3 UC1.AT5
WLAN_CLKREQ#: JMINI.7 RP42.7 UC1.N1
WLAN_RADIO_DIS#_R: JMINI.20 QM30.1 RM110.2
WOL_EN: RL27.2 RL38.1 UE1.98 UL2.3
XDP_DBRESET#: CC17.1 JXDP1.48 RC26.1 RC362.2
XDP_OBS0_R: JXDP1.21 RC141.1 UC1.J60
XDP_OBS1_R: JXDP1.23 RC141.2 UC1.H60
XDP_PRDY#: JXDP1.5 UC1.J62
XDP_PREQ#: JXDP1.3 RP44.3 UC1.K62
XDP_RST#_R: JXDP1.46 RC51.2
XDP_TCK: RP45.2 UC1.E60
XDP_TCLK: JXDP1.57 RC59.2 RC65.1 RP46.5
XDP_TDI: RP44.2 UC1.F63 UC4.6
XDP_TDO: RP45.1 UC1.F62 UC4.3
XDP_TMS: RP44.1 UC1.E61 UC4.8
XDP_TRST#: R2341.1 RC57.1 RP45.3 UC1.E59 UC4.11
XTAL24_IN: CC6.2 RC12.2 RG6.2 UC1.A25 YC2.3
XTAL24_OUT: CC7.2 RC12.1 UC1.B25 YC2.1
XTALIN: CV95.1 RG7.2 RV97.1 UV1.AV33 YV1.1
XTALIN_6511: C79.1 R36.1 U4.41 X1.1
XTALIN_R: CG11.1 RG4.2 RG7.1
XTALOUT: CV94.1 RV97.2 UV1.AU34 YV1.3
XTALOUT_6511: C91.1 R36.2 U4.40 X1.3
XTLI: CL36.2 RG8.2 UL1.29 YL2.1
XTLI_R: CG7.1 RG5.2 RG8.1
XTLO: CL37.2 UL1.28 YL2.3
N197804: RV98.1 UV14.4
N14128350: PR1110.2 PU1100.1
N16988653: PC605.1 PJP600.2 PU600.3
N16988706: PC601.1 PR605.2
N17002462: PC1200.1 PR1201.1 PR1206.1 PU1200.1
N17002482: PR1204.1 PR1209.1 PR1211.1 PU1200.4
N17002518: PR1208.2 PR1209.2 PR1210.1
N17002625: PC1210.1 PR1200.2
N17045846: PC807.1 PR802.2
N17045965: PR842.1 PU800.28
N17045986: PC809.2 PC813.2 PC817.2 PR813.2 PR820.1 PR846.1 PU800.7
N17046050: PR824.2 PU800.13
N17046121: PQ801.4 PQ802.4 PU800.18
N17046167: PC809.1 PC816.2 PR833.1 PR845.1 PU800.8
N17159315: RV84.1 UV1.AB34
N17216117: RV89.2 UV1.AM17
N17407779: CE12.1 R2354.1
N17434554: RE36.2 UE1.107
N17434577: RE7.2 UE1.66
N17438484: CA21.1 R2355.2
N17494823: CA1.1 CA2.1 QA5.2 RA3.2
N17607640: PC300.1 PR300.1 PR301.1 PU300.1
N17607660: PC307.2 PR305.2 PR307.1 PU300.4
N17608587: PC302.1 PR303.2
N17777752: RV244.1 RV245.1 UV1.V28 UV1.W29
N17839157: RV246.1 UV1.AF30
N17841799: RV247.1 UV1.AF31
N17860472: RV26.2 UV4.J13
N18009245: PC708.1 PC717.2 PR704.1 PU701.1
N18009258: PC719.1 PC722.2 PR710.2 PR716.3
N18009264: PL702.1 PR702.4
N18009271: PC707.1 PC717.1 PR717.1 PU701.2
N18009295: PC722.1 PR708.2 PR716.2
N18009369: PR714.2 PU701.9
N18009411: PQ702.4 PR706.1
N18009417: PC715.2 PR722.1
N18009452: PC723.1 PQ708.2 PR724.2
N18009461: PR715.2 PU701.8
N18107051: RV127.1 UV1.AM39
N18262754: RV207.1 UV1.AF33
N18284053: PJPDC.2 PJPDC.3 PL4.1
N18386761: RV31.2 UV3.J13
N18923200: DC1.2 RC10.1
N19505504: T117.1(TP-1) UC1.AD4
N19636367: QA6.2 RA6.2 RA7.2
N19792312: QA5.5 QA5.6 RA2.2
N19794620: QA6.5 QA6.6 RA5.2
N21178712: PQ1.3 PR5.2
N21178859: PC1302.1 PU1300.7
N21219517: RV64.2 UV1.AH16
N21220354: RV203.1 UV1.Y29
N21246320: PQ1201.1 PR1211.2
N21246524: PC1214.1 PQ1201.2 PR1212.2
N21457125: CL33.1 RL19.2 RL20.2 RL39.2 RL40.2
N22117330: R12.2 U1.1 U2.1
N22117472: C8.1 JCRT1.4
N22117533: JCRT1.11 T1.1(TP-1)
N22119803: C89.1 U4.4
N22119877: R32.1 U4.3
N22119883: C46.1 R19.1 U4.50
N22119919: R30.1 U4.7
N22119921: R26.1 U4.13
N22119926: R29.1 U4.10
N22120195: T2.1(TP-1) U4.32
N22120347: R35.2 U4.42
N22120749: Q3.1 R39.1
N22314596: T96.1(TP-1) UL1.26
N22321388: RE37.2 UE1.82
N22941663: LED4.1 RD18.2
N22942544: LED2.1 RD15.2
N22942565: LED3.2 RD16.2
N22942572: LED3.3 RD17.2
N22942580: LED1.1 RD14.2
N23098258: PC1003.2 PR1001.2 PR1002.1 PU1000.2
N23098273: PC1002.1 PJP1000.2 PU1000.5 PU1000.9
N23098353: PC1004.1 PR1003.2 PR1004.1 PU1000.8
N23623264: PD1.6 PD2.3 PR17.1
N25368131: RV25.2 UV5.J13
N25669355: RV30.2 UV6.J13
N26889205: RV198.1 UV1.Y30
N32320781: PQ701.3 PR702.1
N32936693: PQ706.1 PR720.2
N39186606: RV125.1 UV1.AL21
N39195318: RV123.1 UV1.AW28
N39348342: RV122.1 UV1.AW18
N39890903: CV218.1 UV1.AK10
N39890907: CV219.2 RV137.1
N39890909: CV218.2 RV136.1
N39890911: CV222.1 RV143.2 RV144.1
N39890927: CV219.1 UV1.AL10
N39986171: QV24.1 RV107.2 RV108.1
N39986181: CV103.1 QV22.2 RV108.2
N40812716: CR3.2 UR1.6
N45520480: RV206.2 UV1.M27
N46608735: PQ701.2 PR701.1
N46608740: PC702.2 PQ701.4 PR721.2
N46608753: PC701.2 PC702.1 PR701.2 PR703.1
N46612327: PR708.1 PU701.13
N46612330: PR710.1 PU701.12
N46660696: PC520.2 PR534.1
N46662317: PR510.1 PU501.4
N46663656: PC504.1 PR516.2 PU501.2
N46665785: PC514.1 PR529.1
N46673636: PH501.2 PR515.1
N46674251: PL502.2 PR518.2
N46860163: PQ708.1 PR713.2 PU701.10
N46975913: PC501.1 PR536.2
N46975982: PR536.1 PU502.6
N46976065: PC501.2 PU502.7
N47007806: PC16.1 PQ2.3 PR28.2
N47007810: PC16.2 PQ2.2 PR29.1
N47007850: PQ2.5 PR31.1 PR33.2
N47007898: PC14.2 PQ3.5 PR32.1
N47008006: PQ1.5 PQ1.6 PR7.1 PR10.2
N47008110: PC15.1 PQ3.2 PR30.2
N47008134: PL2.2 PQ6.1 PR6.2
N47008301: PQ4.1 PR27.1
N47305899: PC815.2 PR805.1
N47415217: PC104.2 PR103.1
N47415258: PC103.1 PR113.2
N47415272: PC111.1 PR112.2
N47415370: PC110.1 PR111.2
N47417471: PC405.1 PJP400.2 PU400.3
N47417524: PC401.1 PR405.2
N47420895: PC207.2 PR203.1
N47445410: PR114.1 PU100.19
N47894294: CC8.2 RC23.1
N47894380: CC9.2 RC24.1
N47894401: CC10.2 RC25.1
N47938591: T118.1(TP-1) UC1.AN10
N47938593: T119.1(TP-1) UC1.AM10
N47938689: T120.1(TP-1) UC1.E15
N47938710: T121.1(TP-1) UC1.E13
N47964855: T153.1(TP-1) UC1.L60
N47964866: T154.1(TP-1) UC1.N60
N47964871: T155.1(TP-1) UC1.W23
N47964873: T156.1(TP-1) UC1.Y22
N47964879: T157.1(TP-1) UC1.AV62
N47964884: T158.1(TP-1) UC1.D58
N47965485: T146.1(TP-1) UC1.AV63
N47965487: T147.1(TP-1) UC1.AU63
N47965489: T160.1(TP-1) UC1.P20
N47965491: T162.1(TP-1) UC1.R20
N47965493: T159.1(TP-1) UC1.A5
N47965495: T148.1(TP-1) UC1.C63
N47965502: T161.1(TP-1) UC1.E1
N47965509: T149.1(TP-1) UC1.C62
N47965511: T163.1(TP-1) UC1.D1
N47965522: T150.1(TP-1) UC1.B43
N47965524: T164.1(TP-1) UC1.J20
N47965529: T151.1(TP-1) UC1.A51
N47965534: T152.1(TP-1) UC1.B51
N47965536: T165.1(TP-1) UC1.H18
N48037563: JDIMM1.197 RD6.2
N48037565: JDIMM1.201 RD7.2
N48039107: CD21.1 CD22.1 JDIMM1.126 RD4.1
N48051997: CD52.1 CD53.1 JDIMM2.126 RD10.1
N48052813: JDIMM2.197 RD13.1
N48052822: JDIMM2.201 RD12.1
N48120577: RX5.2 UX4.12
N55155843: QX1.1 RX3.2
N56393123: RL31.2 UL1.31
N56393790: T94.1(TP-1) UL1.27
N56393809: T95.1(TP-1) UL1.25
N60531222: RP41.1 UC1.C35
N60531228: RP41.2 UC1.C34
N60531230: RP41.3 UC1.AK8
N60531232: RP41.4 UC1.AL8
N60754677: T111.1(TP-1) UC1.H61
N60754679: T112.1(TP-1) UC1.H62
N60754681: T113.1(TP-1) UC1.K59
N60754683: T114.1(TP-1) UC1.H63
N60754685: T115.1(TP-1) UC1.K60
N60754687: T116.1(TP-1) UC1.J61
N60931942: T97.1(TP-1) UC1.AF2
N60931944: T99.1(TP-1) UC1.AF4
N60931946: T98.1(TP-1) UC1.AD2
N61580896: Q2307.1 R2314.2
N61580898: Q2308.1 R2315.2
N63469417: CA65.2 CA69.1 RA79.1 RA81.2
N63469524: CA68.2 RA82.1
N63469526: CA67.2 RA80.1
N63469613: CA65.1 UA1.12
N63469617: RA51.1 UA1.13
N63469687: CA23.2 UA1.28
N63469697: RA153.2 UA1.15
N63469703: CA24.1 UA1.37
N63469709: CA24.2 UA1.35
N63469711: CA25.2 UA1.34
N63469717: CA62.2 UA1.27
N63469723: CA63.2 UA1.39
N63469729: CA64.2 UA1.7
N63469750: RA130.2 UA1.8
N63642793: C51.1 R264.2 UC1.AH11
N63643467: T53.1(TP-1) UC1.J13
N63643476: T55.1(TP-1) UC1.AH13
N63643505: T56.1(TP-1) UC1.AB8
N63643514: T58.1(TP-1) UC1.AD10
N63643523: T59.1(TP-1) UC1.AD8
N63656577: T38.1(TP-1) UC1.AB23
N63657072: T39.1(TP-1) UC1.P60
N63657081: T40.1(TP-1) UC1.P61
N63657090: T41.1(TP-1) UC1.N59
N63657099: T42.1(TP-1) UC1.N61
N63657120: T43.1(TP-1) UC1.T59
N63657126: T44.1(TP-1) UC1.AD60
N63657135: T45.1(TP-1) UC1.AD59
N63657146: T46.1(TP-1) UC1.AA59
N63657155: T47.1(TP-1) UC1.AE60
N63657164: T48.1(TP-1) UC1.AC59
N63657173: T49.1(TP-1) UC1.AG58
N63657182: T50.1(TP-1) UC1.U59
N63657191: T51.1(TP-1) UC1.V59
N64564173: PC1103.1 PR1101.2
N64564191: PC1106.1 PR1104.2
N64734520: T107.1(TP-1) UC1.AJ7
N64734538: T105.1(TP-1) UC1.AL5
N64734540: T106.1(TP-1) UC1.AP4
N93761952: RV163.2 UV8.J13
N93762059: RV162.2 UV7.J13
N93819115: RV171.2 UV10.J13
N93820861: RV169.2 UV9.J13

Pads without a net: DE2 3; DE3 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JHDD 18 20 21 22; JKB 2 3 30; JLVDS 38; JMINI 1 3 5 8 10 12 14 16 17 19 37 42 45 47; JXDP1 55; LED1 3; LED2 3; LED4 3; PD1 5; PU100 7; PU200 10; PU400 2 5; PU501 5; PU600 2 5; PU800 1; PU1000 7; PU1200 2; PU1300 4; RP37 4 5; RP42 5; RP43 3 4 5 6; RP45 4 5; RP46 3 6; RP48 4 5; RP49 3 4 5 6; RP50 4 5; RP56 1 2; RP57 3 4 5 6; RP60 2 7; U4 18 45; U2301 10 12; U2303 1; U2304 5 6 7 8 9 10 12; UA1 14 16 20 23 24 48; UC1 A31 A37 A41 A49 A53 A55 A57 AA23 AB21 AC2 AC4 AC20 AC58 AD23 AE59 AF20 AG5 AL2 AL11 AL32 AM5 AN3 AN5 AP1 AP15 AP32 AT3 AU2 AU12 AV2 AV10 AV50 AW10 AW49 AY8 AY42 AY43 B14 B31 B37 B41 B49 B50 B53 B54 B55 B57 C3 C4 C15 C17 C30 C31 C42 C43 C46 C47 C49 C50 C51 C53 D17 E2 E3 E4 E5 F4 F5 F15 F17 G2 G15 G17 H6 J4 J6 J58 K4 K10 K18 K21 L2 L3 L11 L59 M20 M21 N2 N58 R5 T2 U2 V21 Y2 Y4 Y5 Y20; UE1 21; UE2 1; UR1 7 14 17 19 23; UV1 AA29 AC10 AC30 AC31 AC32 AD30 AD32 AF32 AF35 AG12 AG32 AG33 AG36 AG38 AH12 AH24 AH26 AH35 AH37 AJ19 AJ20 AJ21 AJ24 AJ26 AJ27 AJ30 AJ31 AJ36 AJ38 AK13 AK17 AK19 AK20 AK21 AK24 AK26 AK27 AK35 AK37 AL19 AL27 AL29 AL30 AL31 AL36 AM19 AM20 AM21 AM26 AM27 AM29 AM30 AN7 AN14 AN20 AN21 AN26 AN36 AP6 AP8 AP10 AP12 AP34 AP35 AP37 AR1 AR3 AR6 AR8 AR10 AR12 AR14 AR16 AR20 AR22 AR24 AR26 AR30 AR32 AR34 AR35 AR37 AT7 AT9 AT11 AT15 AT17 AT19 AT21 AT23 AT25 AT27 AT29 AT31 AT33 AU5 AU6 AU8 AU10 AU12 AU14 AU16 AU20 AU22 AU24 AU26 AU30 AU32 AU35 AU39 AV7 AV9 AV11 AV13 AV15 AV21 AV23 AV25 AV31 AW5 AW6 AW8 AW10 AW12 AW37 E37 F35 F37 G36 G38 H32 H33 H35 H37 J32 J33 J36 J38 K16 K27 K29 K30 K32 K33 K35 K37 L10 L27 L29 L30 L32 L33 L36 L38 M12 M20 M21 M35 M37 N12 N29 N30 N32 N33 N36 N38 P29 P30 P32 P33 P35 P37 R36 R38 T29 T30 T32 T33 T35 T37 U12 U38 V12; UV3 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV4 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV5 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV6 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV7 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV8 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV9 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV10 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UX4 2 23 24 33 34; YC2 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 5031 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 838 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 776 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 157 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 159.7
  TOP w0.254: U2303.4 44.77,67.24 45.26,66.75 46.23,66.75 46.61,66.37 QD2.2 45.89,65.87 45.05,65.03 45.05,64.91 44.87,64.73 R2351.2 R2347.2 43.83,64.73 43.47,65.09 40.72,65.09 39.65,64.02 39.65,59.64 v4(40.25,59.04) 64.74,34.55 94.01,34.55 97.53,38.07 v1(102.52,38.07)
  IN3 w0.254: v1(102.52,38.07) 102.8,38.35 158.41,38.35 162.92,33.84 v1(162.92,27.82)
  BOTTOM w0.254: PR202.1 v1(162.92,27.82)
1.35V_B+: length 6.5
  BOTTOM w0.254: 161.45,18.25 161.45,18.54 161.91,19 162.65,19 163.18,19.53 163.18,23.18 PR208.1
  vias: v2(160.15,18.11)
3/5V_B+: length 31
  TOP w0.203: v1(128.71,19.47) 128.23,18.99 PU100.12
  TOP w0.508: 124.55,29.22 123.35,30.43 v2(120.36,30.43) 119.41,30.43 117.89,28.9 117.89,21.03 119.28,19.63 124.13,19.63 124.51,20.01 128.24,20.01 128.71,19.54 v1(128.71,19.47)
  BOTTOM w0.508: PC105.1 128.54,19.31 v1(128.71,19.47)
  vias: v3(127.16,29.16) v3(127.22,26.3) v3(127.92,29.16) v3(127.98,26.3) v3(128.81,29.16) v3(128.86,26.32)
3V_EN: length 11.5
  TOP w0.203: PU100.6 129.77,15.27 129.95,15.09 129.95,14.9 v3(130.08,14.77)
  TOP w0.254: PR100.1 123.68,13.13 PD101.2 124.49,13.48 v1(125.06,12.91)
  BOTTOM w0.254: v3(130.08,14.77) v2(128.59,14.77) 126.59,14.77 125.35,13.52 125.35,13.51 125.06,13.23 v1(125.06,12.91)
3VALW_PCH:
  vias: v2(139.08,24.3)
3VS: length 0.6
  TOP w0.102: v1(95.58,32.46) v4(94.96,32.46)
3VS_GATE: length 5.5
  TOP w0.102: v2(92.15,26.27) 92.45,26.57 R2318.2
  TOP w0.254: R2318.2 94.44,26.57 C2322.1 95.09,27.06 95.72,27.06 v1(96.21,27.55)
  BOTTOM w0.203: U2301.5 v1(96.21,27.55)
5V_EN: length 5.8
  TOP w0.203: PU100.20 125.84,15.27 125.64,15.07
  TOP w0.254: 125.64,15.07 125.05,14.48 PD101.3 123.61,14.91 v2(122.13,14.91) PR101.1
5VS: length 0.7
  TOP w0.102: v1(97.59,32.07) v4(96.85,32.07)
5VS_GATE: length 3.9
  TOP w0.102: v1(97.18,27.63) 97.18,27.77 v2(96.78,28.18)
  TOP w0.254: C2309.1 96.79,26.49 R2313.2 97.18,26.88 v1(97.18,27.63)
  BOTTOM w0.203: v1(97.18,27.63) 97.01,27.8 U2301.3
+0.675VS: length 106.6
  IN2 w1.016: 155.22,31.89 155.22,53.39 156.4,54.57
  IN3 w1.016: 183.37,64.29 181.75,64.29 180.39,62.93 180.39,61.58 179.07,60.26 175.01,60.26 171.43,56.68 157.85,56.68 ; 105.5,64.91 111.08,64.91 119.74,56.25 154.75,56.25 154.75,56.25 155.39,56.25 155.71,56.56
  vias: v1(105.5,66.42) v1(105.5,65.78) v1(156.86,57.01) v1(156.86,56.37) v1(183.86,66.13) v1(183.86,65.49) v3(154.78,29.86) v3(155.41,29.86) v4(184.19,70.7)
+0.675VSP: length 4.8
  IN2 w0.254: v1(156.83,27.31) v3(158.48,27.31)
  BOTTOM w0.102: v2(157.24,30.53) 156.88,30.18 PC211.1
  BOTTOM w0.203: v3(158.48,27.31) 158.11,26.94 PU200.2
+1.2VSP_B+:
  vias: v2(176.96,177.56)
+1.05V_PGOOD: length 152.5
  TOP w0.102: v1(147.35,152.16) v2(147.35,152.68)
  TOP w0.203: v1(192.84,44.94) 192.47,45.31 185.76,45.31 183.62,43.17 183.62,40.11 183.22,39.71 UE1.122
  IN2 w0.508: v1(192.84,44.94) 193.26,45.36 193.26,47.89 192.73,48.42 192.73,51.48 192.75,51.49 192.75,53.48 193.92,54.65 193.92,55.83 190.78,58.96 190.78,75.35 185,81.13 185,82.55 178.59,88.96 178.59,91.38 172.78,97.2 168.85,97.2 166.36,99.69 166.36,102.89 163.22,106.02 162,106.02 161.57,106.45 161.57,109.34 158.75,112.16 155.77,112.16 154.44,113.5 154.44,118.05 152.45,120.03 152.45,127.48 148.54,131.4 148.54,145.57 147.35,146.76 v1(147.35,152.16)
  BOTTOM w0.203: PU300.2 145.87,154.08 147.35,152.6 v1(147.35,152.16) 147.35,151.81 148.15,151.01 PR308.2
+1.5VS: length 468.9
  TOP w0.508: RC129.1 123.21,95.35 125.24,93.32 125.24,92.2 126.48,90.95 150.78,90.95 152.57,89.16 163.78,89.16 v1(164.51,89.89) ; RA8.1 26.17,14.23 v1(26.95,14.23)
  IN1 w0.508: v1(124.12,128.2) 124.41,128.2 125.49,127.12 132.69,127.12 134,128.43 v1(134,128.46) ; 110.71,34.24 98.61,34.24 95.56,31.19 94.99,31.19 78.03,14.23 60.23,14.23 58.96,12.96 v1(55.85,12.96)
  IN2 w0.254: 122.71,124.91 122.27,125.36 121.63,125.36 121.11,124.84 121.11,120.88 121.36,120.63 v1(121.53,120.63) 121.79,120.63 122.05,120.88 122.05,123.62 122.71,124.28 122.71,124.91
  IN2 w0.508: 34.93,13.41 34.93,22.81 33.68,24.05 33.68,31.25 30.32,34.62 30.32,51.13 28.92,52.52 28.92,57.13 27.14,58.91 27.14,63.99 28.03,64.88 28.03,68.65 31.65,72.27 31.65,94.23 37.56,100.14 42.32,100.14 45.11,102.93 53.24,102.93 59.46,109.15 59.46,115 61.37,116.9 63.83,116.9 82.95,136.01 82.95,137.03 83.85,137.93 84.48,137.93 85.4,138.85 85.4,145.07 86.35,146.02 122.36,146.02 v1(122.39,146.06) 123.03,145.42 123.03,137.74 121.7,136.41 121.7,132.79 123.52,130.96 123.52,128.8 v1(124.12,128.2) 123.52,127.61 123.52,126.87 122.27,125.61 122.27,125.36 ; 34.93,13.41 35.37,12.96 v1(55.85,12.96) ; 34.93,13.41 34.48,12.96 27.65,12.96 26.95,13.66 v1(26.95,14.23) ; v1(164.51,89.89) 164.87,90.25 164.87,95.43 160.31,99.99 157.74,99.99 152.69,105.04 151.88,105.04 151.45,105.47 151.45,107.82 151.83,108.2 151.83,109.28 151.48,109.64 151.48,110.46 146.42,115.52 143.67,115.52 141.55,113.4 139.63,113.4 137.05,115.97 135.21,115.97 133.59,117.59 133.59,123.31 134.26,123.98 134.26,128.2 v1(134,128.46)
  IN3 w0.508: v1(122.39,146.06) 119.72,148.73 115.78,148.73 v1(115.01,149.5)
  BOTTOM w0.254: UC1.J15 121.82,120.34 v1(121.53,120.63)
  BOTTOM w0.508: v1(95.91,149.55) 95.79,149.55 95.3,149.07 JMINI.6 ; JMINI.28 v1(107.3,149.55) ; JMINI.48 115.3,149.21 v1(115.01,149.5)
  vias: v3(111.52,33.44) v3(111.52,32.81) v3(112.15,33.44) v3(112.15,32.81) v3(112.79,33.44) v3(112.79,32.81) v4(111.84,32.12)
+1.05VS: length 195.3
  TOP w0.203: UG1.3 71.43,39.98 71.26,39.81 71.26,39.13 CG2.1
  TOP w0.254: v1(73.13,110.98) 73.55,111.4 RP45.8
  TOP w0.508: v1(86.08,112.25) 86.54,112.25 88.74,110.06 91.41,110.06 91.79,110.44 96.93,110.44 98.39,111.9 102.97,111.9 C43.1 105.58,114.5 108.23,114.5 109.19,113.55 113.58,113.55 115.57,111.56 v1(115.57,111.5) ; v1(118.22,116.92) 117.76,117.37 C88.1 ; v1(87.6,119.96) 87.66,120.03 RC60.1 88.3,119.14 88.31,119.14 88.73,119.14 RC58.1 ; C57.1 v1(131.09,121.04) ; C61.1 122.79,119.96 123.45,120.62 123.45,120.62 123.48,120.65 v1(123.49,120.65) ; v1(128.68,122.44) 129.3,123.06 C62.1 130.6,123.06 C60.1 ; C50.1 123.86,118.32 v1(124.02,118.16) ; PC512.1 v1(86.95,134.82) ; PR533.2 84.19,134.5 v1(83.93,134.77) ; v1(71.89,39.01) CG2.1 ; v1(124.51,118.75) 124.55,118.79 C53.1
  IN1 w0.508: v1(71.89,39.01) 71.3,39.01 65.62,44.68 65.62,51.32 63.51,53.44 44.12,53.44 37.18,60.39 v1(37.18,74.29)
  IN2 w0.508: v1(62.5,95.01) 62.5,94.9 61.62,94.02 46.94,94.02 45.96,94.99 35.3,94.99 32.29,91.98 32.29,76.13 34.13,74.29 v1(37.18,74.29) ; v1(120.97,110.39) 121.8,111.22 124.59,111.22 125.45,112.08 v1(125.87,112.08)
  BOTTOM w0.203: UC1.AG13 123,111.61 123.22,111.83 124,111.83 v1(124.03,111.8) ; UC1.AG14 122.19,111.68 v1(122.01,111.86)
  BOTTOM w0.254: v1(118.19,110.98) 117.94,111.23 UC1.AF22 ; v1(124.02,118.16) 124.51,118.66 v1(124.51,118.75) ; UC1.R21 118.59,117.29 v1(118.22,116.92) 118.59,116.54 UC1.T21 ; UC1.AE9 124.5,112.08 124.22,111.8 v1(124.03,111.8) ; UC1.K9 125.25,119.67 UC1.L10 124.51,118.93 v1(124.51,118.75) ; UC1.AG8 125.25,111.1 UC1.AF9 125.25,111.16 UC1.AE8 125.69,111.9 v1(125.87,112.08) ; UC1.AG16 121.35,110.77 120.98,110.41 120.98,110.41 v1(120.97,110.39) 120.59,110.77 UC1.AG17 ; UC1.H15 121.96,120.99 121.64,121.31 v1(121.58,121.31) ; v1(123.49,121.3) 123.55,121.3 UC1.H11 ; v1(120.61,120.67) 120.94,120.34 UC1.J17 ; UC1.P9 125.69,118.24 UC1.N8 125.69,118.3 UC1.M9 v1(124.51,118.75) ; JXDP1.43 62.7,94.81 v1(62.5,95.01) ; UC1.J11 123.87,120.36 123.57,120.65 v1(123.49,120.65) ; UC1.AE22 UC1.AC22 ; UC1.AE22 v1(118.22,112.04) ; UC1.AE22 117.57,112.04 UC1.AE23 115.7,111.63 v1(115.57,111.5)
  BOTTOM w0.279: JXDP1.44 62.7,97.87 v1(63.21,97.36)
  BOTTOM w0.508: R252.1 80.73,118.56 v1(80.05,118.56) 79.92,118.69 R256.1 ; v1(91.28,129.93) 91.52,129.69 R286.1 ; PR530.1 84,134.69 v1(83.93,134.77)
  vias: v1(63.85,97.36) v1(78.9,121.89) v1(79.53,121.89) v1(80.17,121.89) v1(84.26,122.35) v1(84.63,122.84) v1(85.44,112.25) v1(87.09,131.84) v1(87.72,131.84) v1(118.77,139.01) v1(119.21,139.46) v1(119.65,113.65) v1(119.65,113.01) v1(147.54,127.33) v1(147.54,126.74) v3(143.03,138.82) v3(143.03,138.19) v3(143.03,137.55) v3(143.03,136.92) v3(143.67,138.82) v3(143.67,138.19) v3(143.67,137.55) v3(143.67,136.92) v3(144.3,138.82) v3(144.3,138.19) v3(144.3,137.55) v3(144.3,136.92) v3(144.94,138.82) v3(144.94,138.19) v3(144.94,137.55) v3(144.94,136.92) v4(141.87,136.22)
+1.05VS_APLLOPI: length 31.8
  TOP w0.508: v1(118.22,114.48) 118.25,114.51 C69.1 118.9,117.36 118.33,117.93 118.33,118.03 117.12,119.24 117.12,120.85 116.92,121.05 116.92,123.57 117.11,123.76 117.11,125.68 117.36,125.94 117.36,126.8 v4(117.73,127.17) 118.53,127.97 118.53,129.47 v1(118.52,129.49)
  IN3 w0.508: v1(118.52,129.49) 118.52,129.8 120.04,131.33 120.04,132.47 126.33,138.76 v1(126.33,139.77)
  BOTTOM w0.254: UC1.AA21 118.59,114.1 v1(118.22,114.48) 118.59,114.85 UC1.W21
+1.05VS_ASATA3PLL: length 21.2
  TOP w0.102: v1(124.3,142.12) v4(124.3,142.86)
  IN3 w1.016: 126.01,133.93 126.01,136.34 128.05,138.38 128.05,140.92 127.16,141.81 125.19,141.81
  BOTTOM w0.203: 123.88,125.1 123.76,125.1 UC1.B11
  BOTTOM w0.381: C63.1 125.1,130.4 v1(125.1,128.47) 125.1,126.93 124.37,126.21 124.37,125.38 124.09,125.1 123.88,125.1
  BOTTOM w0.508: RC126.2 123.69,132.03 124.18,131.53 RC131.2 124.65,131.76 124.65,132.51 124.96,132.81
  vias: v1(123.66,142.12) v1(125.53,132.84) v1(126.11,132.84)
+1.05VS_AUSB3PLL: length 24.4
  TOP w0.102: v4(114.07,131.65) v1(114.07,131.07)
  IN2 w0.508: v1(114.08,131.07) 114.53,131.53 118.79,131.53 120.62,133.36 v1(120.62,134.25)
  BOTTOM w0.102: 114.12,125.9 114.12,125.22 UC1.B27
  BOTTOM w0.254: UC1.B18 119.37,124.95 119.37,125.32 119.28,125.42 119.28,126.24 120.29,127.25 120.29,127.78
  BOTTOM w0.305: 114.12,125.9 114.12,126.29 114.45,126.62 114.45,128.59 RC91.1 113.75,130.11 114.08,130.44 v1(114.08,131.07)
  BOTTOM w0.508: 120.29,127.78 120.29,131.26 C58.1 120.48,131.86 119.66,132.67
+1.05VS_AXCK_DCB: length 4.3
  BOTTOM w0.254: v1(119.6,120.66) 119.74,120.66 UC1.J18 120.06,120.34 UC1.K19
  BOTTOM w0.508: L4.2 121.76,137.75 121.3,137.3 C84.1 121.67,136.66 v1(122.3,136.03)
  vias: v4(122.43,133.63)
+1.05VS_AXCK_LCPLL: length 16
  BOTTOM w0.254: 118.76,126.42 UC1.A20
  BOTTOM w0.381: 118.76,126.42 119.71,127.38 119.71,131.36 C85.1
  BOTTOM w0.508: C85.1 119.61,131.7 118.71,132.6 ; 118.71,132.6 118.61,132.7 118.61,133.78 C86.1 118.2,134.91 L5.2 ; 118.71,132.6 118.65,132.6 117.18,131.14 117.18,130.85 v4(116.87,130.53) 116.87,130.54 116.46,130.13 RC13.2
+1.05VSP: length 18.1
  IN1 w0.254: v1(149.53,153.72) 150.23,153.72 150.65,153.3 150.65,147.58 149.89,146.82 149.89,142.76 148.49,141.36 v3(146.27,141.36)
  BOTTOM w0.254: v1(149.53,153.72) PR305.1 PC307.1
  vias: v2(147.65,140.71) v3(140.68,143.14) v3(141.32,143.14) v3(142.33,143.14) v3(142.97,143.14) v3(143.92,143.14) v3(144.56,143.14) v3(145.32,143.14) v3(145.95,143.14) v3(146.78,143.14) v3(147.41,143.14)
+1.5VSP: length 9
  IN1 w0.254: v1(112.61,30.36) 113.68,29.3 v1(113.68,25.33)
  BOTTOM w0.102: v2(107.21,33.96) 107.58,33.6 107.58,32.07
  BOTTOM w0.254: PR403.1 PC404.1 v1(113.68,25.33)
+1.5VSP_ON: length 5.1
  BOTTOM w0.102: PR401.1 114.31,26.85 v2(114.66,27.19)
  BOTTOM w0.254: PU400.7 110.37,26.9 110.56,27.09 111.59,27.09 PC403.1 PR404.1 PR401.1
+1.8VGA: length 10.2
  TOP w1.016: 24.86,114.23 v2(26.38,114.23) 27.21,114.23 30.32,115.82 34.7,115.82
+1.8VGAP: length 5
  BOTTOM w0.254: 41.68,116.01 41.68,116.33 41.49,116.52 v2(39.21,116.52) 38.19,116.52 38.08,116.41 PC1003.1 PR1001.1
  vias: v1(40.01,115.45) v1(40.01,114.82) v1(41.61,115.48) v1(41.61,114.84)
+1.8VGS: length 386.5
  TOP w0.203: CG1.1 71.83,44.21 72.16,43.88 72.16,43.36 72.23,43.29 UG1.11
  TOP w0.508: v1(168.69,100.47) 167.92,99.7 166.61,99.7 166.38,99.47 RV237.1 ; RV239.1 v1(157.57,109.27) RV243.1 156.87,109.03 156.48,108.64 154.76,108.64 154.62,108.5 v4(153.86,108.5) 153.51,108.85 153.51,109.67 153.76,109.93 153.76,110.63 153.38,111.01 LV17.1 ; v1(72.61,45.3) 72.01,44.7 CG1.1 ; RV118.2 160.56,102.75 v1(160.05,102.24) 159.93,102.12 157.13,102.12 156.56,102.69 RV124.1 ; v1(190.65,94.05) 190.65,96.78 v1(192.5,98.62) ; v1(158.91,115.58) 159.1,115.58 159.92,114.75 161.03,114.75 161.56,114.23 ; v1(162.92,110.94) 162.92,111.39 LV12.2 162.12,111.73 161.3,112.54 RV241.1 160.81,113.8 161.24,114.23 161.56,114.23 ; LV21.1 203.72,149.62 204.01,149.91 v1(204.01,154.82) ; 161.56,114.23 LV13.2
  IN1 w0.508: v1(192.5,98.62) 192.5,98.56 191.92,97.98 189.94,97.98 189.1,98.82 186.63,98.82 185.97,99.49 184.22,99.49 183.86,99.13 v1(183.22,99.13) 182.83,99.13 182.82,99.11 175.24,99.11 174.21,100.14 174.21,100.89 173.3,101.81 172.25,101.81 171.41,100.97 169.19,100.97 v1(168.69,100.47)
  IN2 w0.508: v1(162.92,110.94) 162.92,110.52 162.34,109.93 162.34,107.81 168.69,101.46 v1(168.69,100.47) ; v1(192.99,58.38) 192.99,57.65 194.56,56.09 194.56,54.25 194.15,53.85 194.15,44.46 193.6,43.91 v1(193.39,43.91)
  IN3 w0.508: v1(158.91,115.58) 160.57,117.24 160.57,124.9 157.9,127.57 157.9,139.18 159.73,141 159.73,151.78 161.37,153.43 161.37,155.36 162.61,156.6 200.69,156.6 202.47,154.82 v1(204.01,154.82)
  BOTTOM w0.508: v1(193.39,43.91) 193.36,43.89 190.87,43.89 190.16,44.6 185.06,44.6 183.3,42.85 121.85,42.85 118.04,39.04 111.98,39.04 106.27,44.74 76.34,44.74 75.19,45.9 73.21,45.9 v1(72.61,45.3) ; LV22.1 191.75,94.28 191.52,94.05 ; RV71.1 192.88,99 v1(192.5,98.62) ; RV71.1 RV69.1 ; RV71.1 RV67.1 ; LV19.1 167.73,97.92 167.73,99.51 167.92,99.7 ; 167.92,99.7 v1(168.69,100.47) ; 167.92,99.7 163.86,99.7 162.25,101.3 160.98,101.3 v1(160.05,102.24) 159.89,102.39 159.89,103.17 159.54,103.52 LV16.1 LV14.2 ; RV119.1 183.22,99.13 v1(183.22,99.13) 183.72,99.13 LV20.1 RV93.2 ; v1(158.91,115.58) 157.71,115.58 156.88,114.75 LV18.1 155.88,114.75 155.44,114.31 155.44,111.75 155.77,111.42 155.77,110.81 157.31,109.27 v1(157.57,109.27) ; 186.52,86.15 186.52,65.59 191.48,60.63 191.48,59.87 192.97,58.38 v1(192.99,58.38) ; 191.52,94.05 191.52,91.74 188.4,88.62 187.77,88.62 186.47,87.32 ; 191.52,94.05 v1(190.65,94.05)
+1.8VS: length 32.9
  IN1 w1.016: 185.45,86.81 187.54,86.81 189.96,89.23 209.01,89.23 211.93,92.15 212.44,92.15 214.31,94.02
  BOTTOM w0.102: v1(184.43,87.07) v2(183.33,87.07)
  vias: v1(184.43,86.48) v1(215.23,95.26) v1(215.23,94.63) v1(215.23,94.04)
+1.8VS_DAC: length 20.3
  TOP w0.508: L12.2 19.71,111.38 v1(16.86,111.38)
  IN2 w0.508: v1(16.86,111.38) 15.69,111.38 14.98,110.66 14.98,109.45 15.97,108.46 15.97,106.97 v1(16.56,106.38) ; v1(16.52,101.92) 16.27,101.66 v1(13.81,101.66)
  BOTTOM w0.127: v2(17.43,111.38) v1(16.86,111.38)
  BOTTOM w0.203: v1(16.52,101.92) 16.6,102 U4.5 ; v1(16.48,104.77) 16.85,104.4 U4.11 ; U4.14 17.11,105.59 16.56,106.15 v1(16.56,106.38) ; U4.8 16.4,103.2 v1(16.16,103.44)
  BOTTOM w0.508: C89.2 14.11,101.66 v1(13.81,101.66)
+1.8VS_RXVCC: length 9.4
  TOP w0.127: C48.1 v2(27.97,103.57)
  TOP w0.508: C93.1 23.65,108.52 v1(23.27,108.14) ; v1(25.62,103) 26.19,103.57 C48.1
  BOTTOM w0.203: U4.35 25.42,103.2 v1(25.62,103) ; U4.29 25.43,105.59 v1(25.62,105.79) ; v1(23.02,107.31) 22.85,107.14 U4.26 ; U4.38 25.16,102 v1(25.49,101.66) 25.43,101.6 U4.39
  BOTTOM w0.254: v1(23.27,108.14) C80.1
  vias: v1(25.25,112.32) v1(25.25,111.73)
+1.8VS_RXVDD: length 14.6
  BOTTOM w0.203: v1(23.65,102.39) 23.65,102.4 U4.37 ; C31.1 19.07,108.01 19.07,107.24 19.25,107.06 U4.17 ; U4.15 18.45,106.92 17.81,107.56 17.81,108.38 C29.1 ; U4.52 20.05,98.87 20.21,98.71 20.21,98.12 C28.1 ; v1(21.25,98.64) U4.49 ; v1(24.34,106.9) 24.19,107.05 23.77,107.05 23.65,106.93 U4.28
  BOTTOM w0.508: v1(16.77,110.49) 16.77,109.18 17.19,108.76 C29.1 ; C30.1 23.38,97.61 v1(23.52,97.75) ; v1(18.29,108.11) 18.29,108.74 C31.1 ; v1(19.65,98.38) 19.65,97.95 C28.1
  vias: v1(20.64,110.86) v1(21.23,110.86) v1(24.34,107.48) v2(25.01,107.25)
+1.8VSP: length 19.9
  BOTTOM w0.254: v1(215.48,97.23) 217.6,99.35 220.99,99.35 221.45,98.88 222.72,98.88 223.36,98.24 223.36,90.1 PR603.1 PC604.1
  vias: v1(217.2,97.23) v1(218.66,98.82) v1(218.66,96.43) v1(218.66,95.82) v2(216.35,98.84)
+1.8VSP_ON: length 6.6
  TOP w0.102: v2(221.63,93.81) 221.63,93.09 221.44,92.91 v1(221.01,92.91)
  TOP w0.508: PR601.1 219.16,93.36 PR604.1 PC603.1 220.55,93.37 v1(221.01,92.91)
  BOTTOM w0.254: PU600.7 219.54,93 219.72,93.18 220.74,93.18 v1(221.01,92.91)
+1.35V: length 141.2
  TOP w0.356: RD3.1 48.7,64.23 QD2.1 48.7,65.8 v1(48.43,66.06) 48.02,66.06 47.51,66.57 CD23.1 ; U2303.5 43.47,67.42 43.34,67.29 43.19,67.29 42.52,66.62 41.24,66.62 v1(40.73,66.11)
  IN2 w0.508: v1(40.73,66.11) 46.83,66.11 49.11,63.83 64.23,63.83 65.69,65.29 v1(66.89,65.29)
  BOTTOM w0.203: UC1.AY35 109.38,102.88 109.38,101.33 v1(109.86,100.85) ; UC1.AY40 106.27,102.92 106.27,102.11 v1(106.69,101.69) ; v1(101.03,105.72) 101.36,106.04 UC1.AR48 ; v1(103.56,101.93) 103.32,101.93 103.09,102.16 103.09,102.89 UC1.AY44
  BOTTOM w0.229: v1(100.4,102.38) 99.98,102.79 UC1.AY50
  BOTTOM w0.254: UC1.AJ33 v1(110.51,110.51) ; UC1.AJ31 v1(111.81,110.51) ; v1(103.89,106.37) 104.06,106.37 UC1.AP43 ; v1(110.1,107.01) 110.22,107.01 UC1.AN33 ; v1(114.41,110.51) 114.82,110.51 UC1.AH26 ; UC1.AJ37 v1(107.9,110.51)
  BOTTOM w0.356: JDIMM2.75 144.95,72.56 v1(145.27,72.88) 145.28,72.88 146.23,72.88 146.75,72.36 JDIMM2.81 ; JDIMM2.88 148.85,64.68 v1(149.08,64.91) 148.9,65.1 147.54,65.1 147.05,64.61 JDIMM2.82 ; JDIMM1.75 66.4,72.52 66.66,72.78 v1(67.39,72.78) 68.04,72.78 68.2,72.62 JDIMM1.81 ; JDIMM2.94 150.65,64.21 v1(151.16,64.72) ; JDIMM2.93 150.35,72.63 v1(150.08,72.9) 148.89,72.9 148.55,72.56 JDIMM2.87 ; JDIMM1.111 77.2,73.65 v1(76.74,74.11) ; JDIMM2.118 157.85,64.49 158.28,64.91 v1(158.62,64.91) 159.28,64.91 159.65,64.54 JDIMM2.124 ; v1(153.62,65.29) 153.59,65.33 153.19,65.33 152.45,64.59 JDIMM2.100 ; JDIMM1.82 68.5,64.89 68.1,65.29 v1(66.89,65.29) 66.77,65.29 66.45,64.97 66.45,64.96 66.37,64.88 66.37,64.44 66.45,64.36 66.7,64.11 JDIMM1.76 ; JDIMM2.106 154.25,64.38 154.67,64.8 v1(155.53,64.8) 156.05,64.27 JDIMM2.112 ; JDIMM1.87 70,72.52 70.34,72.86 v1(71.53,72.86) 71.8,72.59 JDIMM1.93 ; JDIMM1.118 79.3,64.23 79.64,64.57 v1(80.38,64.57) 80.76,64.57 81.1,64.23 JDIMM1.124 ; v1(70.27,64.89) 70.3,64.85 JDIMM1.88 ; JDIMM2.99 152.15,72.41 152.64,72.91 v1(152.94,72.91) 153.59,72.91 153.95,72.55 JDIMM2.105 ; JDIMM1.117 79,72.7 79.54,73.24 v1(80.42,73.24) 80.8,72.86 JDIMM1.123 ; v1(75.47,72.84) 75.4,72.78 JDIMM1.105 ; JDIMM2.76 145.25,64.28 145.24,64.28 145.24,64.88 v1(145.27,64.91) ; JDIMM1.112 77.5,64.8 v1(77.59,64.89) ; JDIMM1.99 73.6,72.5 74.51,73.42 75.72,73.42 v1(75.91,73.23) ; JDIMM2.117 157.55,72.61 157.26,72.9 v1(156.94,72.9) 156.93,72.9 156.78,72.75 156.15,72.75 156.14,72.74 156.03,72.74 155.75,72.46 JDIMM2.111 ; JDIMM2.123 159.35,72.46 158.97,72.84 v1(158.62,72.84) ; JDIMM1.94 72.1,64.7 v1(71.92,64.89) ; JDIMM1.106 75.7,64.29 75.41,64.58 v1(73.61,64.58) 73.9,64.29 JDIMM1.100
  BOTTOM w0.508: RC15.1 94.59,90.04 94.96,89.67 v1(95.41,89.67) 96.67,89.67 96.99,89.99 RC16.1 97.33,90.44 RC14.1 ; v1(48.43,66.06) 40.78,66.06 v1(40.73,66.11)
  vias: v1(65.15,69.44) v1(65.15,67.92) v1(66.45,61.46) v1(66.45,59.94) v1(66.45,58.41) v1(66.75,69.44) v1(66.75,67.92) v1(66.75,66.4) v1(67.97,61.46) v1(67.97,59.94) v1(67.97,58.41) v1(70.27,67.94) v1(70.27,66.41) v1(70.95,61.46) v1(70.95,59.94) v1(70.95,58.41) v1(71.92,67.94) v1(71.92,66.41) v1(73.56,61.46) v1(73.56,59.94) v1(73.56,58.41) v1(73.77,69.46) v1(73.77,67.94) v1(73.77,66.41) v1(75.13,69.84) v1(75.13,67.56) v1(75.2,61.84) v1(75.2,59.55) v1(75.78,60.7) v1(76.23,68.7) v1(77.59,67.94) v1(77.59,66.41) v1(77.63,61.46) v1(77.63,59.94) v1(77.63,58.41) v1(78.98,67.94) v1(78.98,66.41) v1(79.66,61.46) v1(79.66,59.94) v1(79.66,58.41) v1(80.51,69.46) v1(80.51,67.94) v1(80.51,66.41) v1(98.84,97.99) v1(101.69,98.05) v1(103.58,99.64) v1(105.31,99.6) v1(105.3,98.98) v1(108.22,98.6) v1(108.22,97.96) v1(110.01,97.55) v1(143.32,66.44) v1(143.32,64.91) v1(144.84,67.96) v1(144.84,66.44) v1(145.78,61.5) v1(145.78,59.97) v1(145.78,58.45) v1(146.58,67.96) v1(146.58,66.44) v1(147.43,61.5) v1(147.43,59.97) v1(147.43,58.45) v1(149.08,69.48) v1(149.08,67.96) v1(149.08,66.44) v1(149.08,61.5) v1(149.08,59.97) v1(149.08,58.45) v1(150.62,61.5) v1(150.62,59.97) v1(151.16,69.48) v1(151.16,67.96) v1(151.16,66.44) v1(152.72,60.74) v1(153.37,68.34) v1(153.37,66.05) v1(153.75,61.88) v1(153.75,59.59) v1(154.48,67.19) v1(155.87,67.96) v1(155.87,66.44) v1(156.04,61.5) v1(156.04,59.97) v1(157.43,67.96) v1(157.43,66.44) v1(157.56,61.5) v1(157.55,59.26) v1(157.55,57.74) v1(158.96,67.96) v1(158.96,66.44) v3(145.9,29.8) v3(146.53,29.8) v3(147.17,29.8) v3(147.86,29.79) v3(148.49,29.79) v3(149.13,29.8) v3(149.77,29.8) v3(150.59,29.8) v3(151.23,29.8) v4(93.68,78.63)
+1.35V_MEM_GFX: length 362.8
  TOP w0.254: CV155.1 187.69,112.59 v1(187.69,112.59)
  TOP w0.305: UV3.G4 190.82,150.36 190.84,150.36 v1(191.2,150) ; UV9.M14 v1(203.97,115.11) ; v1(187.19,145.18) 187.59,144.78 UV3.L11 ; v1(188.79,143.58) 188.4,143.98 UV3.K12 ; v1(205.76,109.87) 206.17,110.28 UV9.F12 ; UV9.L13 205.37,114.44 205.96,115.03 206.09,115.03 UV9.M12 v1(205.77,115.51) ; UV3.M14 186.8,141.78 v1(186.79,141.78) ; UV9.B3 212.97,106.71 v1(212.97,106.71) ; UV5.L2 167.09,152.06 v1(167.45,152.43) ; UV9.D1 215.56,108.71 v1(215.61,108.65) ; v1(191.99,145.98) 192.39,145.58 UV3.E10 ; v1(168.28,143.65) 167.89,144.05 UV5.K12 ; 173.48,145.65 v1(173.08,145.25) UV5.D11 ; 173.48,145.65 v1(173.08,146.05) ; 173.48,145.65 UV5.C10 ; UV3.R5 v1(183.99,149.18) ; v1(170.28,141.8) 170.29,141.8 UV5.G14 ; v1(171.48,146.05) 171.88,145.65 UV5.E10 ; UV3.F14 v1(191.6,141.75) ; UV5.H12 169.49,144.04 v1(169.89,143.64) 170.28,143.25 UV5.G13 ; UV9.E10 207.77,109.51 v1(208.17,109.91) ; UV5.D1 172.69,153.43 v1(172.74,153.49) ; UV7.T3 v1(213.16,139.11) ; v1(174.29,141.81) 174.29,142.44 174.29,142.45 UV5.B14 ; UV9.P2 UV9.P1 v1(215.54,116.71) ; v1(213.96,133.51) 213.92,133.55 UV7.K3 ; UV3.N10 v1(186.39,145.98) ; v1(204.16,135.51) 204.16,135.51 UV7.M14 ; v1(171.52,143.64) 171.11,144.05 UV5.F12 ; v1(212.19,110.71) 212.55,111.07 212.55,111.09 UV9.G4 ; UV3.T12 v1(183.19,143.58) ; UV9.N10 v1(208.17,115.51) ; v1(205.77,113.11) 206.17,113.51 UV9.K12 ; UV9.G11 v1(207.37,110.71) ; v1(206.76,127.11) 206.36,127.51 UV7.B12 ; UV3.J1 v1(189.59,153.18) ; UV7.P12 206.36,137.11 v1(206.76,137.51) ; UV5.G11 v1(170.68,145.25) ; UV3.D1 193.2,153.37 v1(193.25,153.43) ; v1(192.04,143.57) 191.63,143.98 UV3.F12 ; UV5.R10 163.89,145.65 164.29,146.05 v1(164.28,146.05) ; v1(204.01,108.71) UV9.D14 UV9.D13 ; UV9.J1 v1(215.37,112.31) ; UV5.F14 v1(171.09,141.81) ; v1(185.94,149.06) 185.94,149.05 185.94,149.53 UV3.N5 ; UV9.L2 214.18,114.31 v1(214.55,113.94) ; UV7.D13 UV7.D14 v1(204.2,129.11) ; UV5.B3 174.68,150.85 v1(174.69,150.85) ; v1(212.38,131.1) 212.74,131.47 212.74,131.48 UV7.G4 ; UV5.L1 167.09,152.91 v1(167.44,153.26) ; v1(184.79,144.38) 185.19,143.98 UV3.P12 ; UV3.L4 187.66,150.45 187.66,150.45 v1(188,150.79) 188.39,151.18 UV3.K3 ; UV5.G2 170.23,152.05 v1(169.83,151.65) 169.49,151.3 UV5.H3 ; v1(213.16,134.31) 212.83,134.64 212.83,134.64 UV7.L4 ; UV5.F3 v1(171.48,151.65) ; UV7.M3 213.56,135.51 v1(213.96,135.91) ; UV9.C5 v1(212.17,107.51) ; v1(163.48,150.85) 163.08,151.25 UV5.T3 ; v1(168.28,153.87) 168.37,153.87 168.81,153.43 168.81,152.98 UV5.J1 ; v1(207.56,137.51) 207.16,137.11 UV7.P11 ; v1(215.75,130.69) 215.18,130.69 UV7.F1 ; v1(215.68,131.58) 215.62,131.58 215.54,131.51 UV7.G1 ; UV3.M3 186.79,151.18 v1(186.39,151.58) ; UV9.T14 v1(203.97,118.31) ; v1(204.01,116.71) UV9.P14 ; v1(215.56,132.71) 215.56,132.71 215.17,133.11 UV7.J1 ; UV5.R5 v1(163.48,149.25) ; UV3.P2 v1(184.79,151.58) 185.19,151.18 UV3.P3 ; UV5.K3 168.24,151.6 168.24,151.6 v1(168.28,151.65) ; UV9.R5 v1(211.37,117.91) ; v1(205.95,130.27) 206.36,130.68 UV7.F12 ; UV9.D11 v1(207.37,108.31) UV9.C10 207.77,107.91 v1(208.17,108.31) ; v1(204.12,127.5) 204.75,127.5 204.76,127.51 UV7.B14 ; UV3.G11 v1(191.19,145.18) ; v1(187.95,153.2) 187.6,152.85 UV3.L1 ; UV9.K3 213.37,113.51 v1(212.97,113.91) 212.64,114.24 212.64,114.24 UV9.L4 ; UV9.P3 212.97,117.11 v1(212.97,117.11) ; UV9.D3 213.37,108.71 v1(212.97,108.31) ; UV7.H12 206.35,132.31 v1(205.95,131.91) 205.56,131.51 UV7.G13 ; UV9.T1 214.99,118.31 ; UV3.G14 190.8,141.74 v1(190.79,141.73) ; v1(207.37,114.71) 206.97,114.31 UV9.L11 ; UV5.P12 v1(164.28,144.45) ; v1(213.16,128.71) 213.56,129.11 UV7.D3 ; UV5.E5 171.88,149.65 v1(171.48,150.05) ; UV5.D13 UV5.D14 v1(172.69,141.88) ; UV5.T12 v1(162.68,143.65) ; UV7.F3 v1(213.96,130.31) ; v1(205.96,133.51) 206.36,133.91 UV7.K12 ; UV3.D12 v1(193.59,144.38) ; v1(208.36,130.31) 207.96,129.91 UV7.E10 ; UV5.D3 172.69,151.25 v1(173.08,150.85) ; UV3.H3 190,151.24 v1(190.34,151.58) 190.75,151.98 UV3.G2 ; UV9.G2 214.17,111.16 v1(213.77,111.56) 213.42,111.91 UV9.H3 ; UV7.P3 v1(213.16,137.51) ; UV7.P2 UV7.P1 215.73,137.11 v1(215.73,137.11) ; UV7.H3 213.61,132.31 v1(213.96,131.96) 214.36,131.56 UV7.G2 ; UV7.T1 215.18,138.71 ; UV7.D11 v1(207.56,128.71) UV7.C10 207.96,128.31 v1(208.36,128.71) ; v1(215.58,134.36) 215.23,134.71 UV7.L1 ; UV9.F3 v1(213.77,109.91) ; UV3.P1 v1(185.2,153.36) ; UV7.B1 215.21,127.51 v1(215.56,127.16) ; UV3.T3 v1(183.99,150.78) ; UV7.N10 v1(208.36,135.91) ; UV7.R5 v1(211.56,138.31) ; UV9.L14 v1(204,114.31) ; UV3.R10 184.8,145.98 v1(184.79,145.98) ; UV5.T14 v1(163.08,141.85) ; UV7.C5 211.96,128.31 v1(212.36,127.91) ; UV7.T14 v1(204.25,138.71) ; UV5.T1 163.08,152.87 ; v1(194.39,149.98) 194,149.58 UV3.C5 ; v1(203.92,111.12) 203.92,111.11 UV9.G14 ; UV7.B3 213.16,127.11 v1(213.16,127.1) ; UV3.B12 194.8,143.99 v1(195.19,144.38) ; UV7.D12 v1(206.76,128.71) ; UV5.G4 170.31,150.42 170.33,150.42 v1(170.69,150.06) ; UV5.B12 v1(174.68,144.45) ; v1(169.99,153.47) 169.99,153.14 UV5.G1 ; UV5.M14 v1(166.28,141.85) ; UV5.L14 v1(167.09,141.88) ; v1(186.39,143.58) UV3.M12 186.88,143.9 186.88,143.78 187.47,143.18 UV3.L13 ; UV7.L13 205.56,134.83 206.15,135.42 206.28,135.42 UV7.M12 v1(205.96,135.91) ; UV9.E5 211.77,109.51 v1(212.17,109.91) ; UV7.F14 v1(204.12,130.71) ; v1(195.2,150.79) 195.19,150.79 UV3.B3 ; UV3.F3 v1(191.99,151.58) ; UV5.N5 165.43,149.6 165.43,149.11 v1(165.43,149.12) ; UV3.B14 194.8,142.38 194.8,142.37 v1(194.8,141.74) ; UV9.G1 215.26,111.4 v1(215.59,111.4) ; v1(191.62,153.37) 191.62,152.8 UV3.F1 ; v1(204.2,137.11) UV7.P14 ; v1(166.33,153.43) 166.33,152.89 UV5.M1 ; v1(213.77,115.51) 213.37,115.11 UV9.M3 ; v1(214.74,134.34) 214.37,134.71 UV7.L2 ; UV3.D13 v1(193.59,143.58) ; UV5.P2 v1(164.28,151.65) UV5.P3 ; UV9.L1 215.04,114.31 v1(215.39,113.96) ; UV9.F14 v1(203.93,110.31) ; v1(185.2,141.82) UV3.P14 ; v1(208.36,137.51) 208.36,137.51 UV7.R10 ; v1(195.14,153.18) 194.8,152.84 UV3.B1 ; UV3.T1 183.6,152.8 ; v1(215.56,110.29) 214.99,110.29 UV9.F1 ; UV5.P11 v1(164.28,145.25) ; UV3.P11 185.19,144.78 v1(184.79,145.18) ; UV9.B14 204.57,107.11 204.56,107.1 v1(203.93,107.1) ; UV5.C5 v1(173.88,150.05) ; v1(171.11,153.43) 171.11,152.87 UV5.F1 ; UV5.M3 v1(165.88,151.65) ; UV7.L11 207.16,134.71 v1(207.56,135.11) ; UV9.B12 v1(206.57,106.71) ; UV9.R10 v1(208.17,117.11) ; UV7.D1 215.75,129.11 v1(215.81,129.05) ; UV3.G13 190.79,143.18 v1(190.4,143.57) 190,143.98 UV3.H12 ; v1(204.11,131.51) 204.11,131.51 UV7.G14 ; UV7.G11 v1(207.56,131.11) ; v1(174.63,153.25) 174.29,152.9 UV5.B1 ; v1(215.74,135.46) 215.21,135.46 UV7.M1 ; UV7.L14 v1(204.19,134.71) ; v1(207.37,117.11) 206.97,116.71 UV9.P11 ; v1(193.59,150.78) 193.2,151.18 UV3.D3 ; v1(165.88,143.65) UV5.M12 166.37,143.97 166.37,143.84 166.96,143.25 UV5.L13 ; UV5.D12 v1(173.08,144.45) ; v1(193.59,145.98) 193.99,145.58 UV3.C10 v1(193.59,145.18) UV3.D11 ; UV5.L4 167.15,150.52 167.15,150.52 v1(167.49,150.85) ; UV5.P1 v1(164.68,153.42) ; UV3.L2 187.6,151.99 v1(187.96,152.36) ; UV3.M1 186.84,152.83 v1(186.84,153.36) ; UV9.B1 215.02,107.11 v1(215.37,106.76) ; v1(211.43,136.36) 211.43,136.36 211.91,136.36 UV7.N5 ; UV9.T12 v1(205.77,118.71) ; UV3.L14 v1(187.6,141.82) ; UV9.D12 v1(206.57,108.31) ; UV3.G1 190.5,153.08 v1(190.5,153.4) ; UV9.G13 205.37,111.12 v1(205.76,111.51) 206.16,111.91 UV9.H12 ; UV9.T3 v1(212.97,118.71) ; v1(191.99,149.98) 192.39,149.58 UV3.E5 ; v1(193.2,141.82) UV3.D14 ; UV9.P12 206.17,116.71 v1(206.57,117.11) ; UV7.E5 211.96,129.91 v1(212.36,130.31) ; UV7.T12 v1(205.96,139.11) ; UV9.N5 211.72,115.96 211.24,115.96 v1(211.24,115.97) ; v1(166.68,145.25) 167.08,144.85 UV5.L11 ; v1(215.55,115.06) 215.02,115.06 UV9.M1 ; UV5.N10 v1(165.88,146.05) ; v1(164.68,141.88) UV5.P14 ; UV3.T14 v1(183.6,141.78)
  TOP w0.375: v1(162.65,153.24) 162.72,153.24 163.08,152.87 ; 215.18,138.71 215.55,139.08 v1(215.55,139.14) ; v1(215.36,118.74) 215.36,118.68 214.99,118.31 ; v1(183.16,153.17) 183.23,153.17 183.6,152.8
  TOP w0.508: RV10.1 204.63,144.6 v1(204.44,144.79) 204.18,144.79 203.74,144.35 CV26.1 ; v1(186.88,122.21) 186.72,122.05 186.72,120.12 v1(185.96,119.35) 185.96,118.38 186.08,118.25 CV156.1 ; v1(216.88,122.69) 216.88,122.72 217.74,123.58 CV5.1 CV4.1 218.53,122.37 CV139.1 ; v1(200.94,130.31) 200.55,129.92 RV12.1 200.33,129.46 200.33,128.56 CV28.1 ; v1(200.69,115.19) 200.31,114.81 CV34.1 RV19.1 ; v1(190.66,138.5) 190.28,138.12 CV350.1 RV193.1 ; v1(201.87,154.29) 201.87,156.69 201.51,157.05 RV32.1 CV389.1 ; RV21.1 CV36.1 ; CV36.1 211.48,99.18 211.35,99.05 RV138.1 ; CV36.1 v1(211.87,98.44) ; RV42.1 RV43.1 174.46,126.87 v1(174.93,126.4) ; v1(189.27,127.92) 189.49,127.71 190.47,127.71 190.85,127.33 RV47.1 ; v1(187.65,109.88) 187.65,109.88 188.3,109.23 CV154.1 ; CV153.1 CV142.1 171.5,132.14 171.5,131.11 172.12,130.48 172.14,130.48 v1(172.47,130.15) 172.17,130.15 171.31,129.29 CV143.1 ; v1(185.7,109.92) 186.19,109.43 CV144.1 ; RV183.1 CV328.1 171.07,138.19 v1(171.43,137.82) ; RV48.1 187.47,115.66 v1(186.89,115.09) ; v1(189.95,116.38) 190.16,116.17 RV49.1
  IN2 w0.508: v1(218.02,143.65) 217.33,143.65 216.88,143.2 216.88,140.47 v1(215.55,139.14) ; v1(172.47,130.15) 172.32,130.15 171.66,129.49 169.57,129.49 168.81,130.25 165.89,130.25 165.38,129.74 164.24,129.74 v1(163.99,129.49)
  BOTTOM w0.254: v1(176.05,129.8) 176.14,129.89 UV1.G23 ; UV9.L13 205.43,114.37 205.43,114.57 205.89,115.03 206.09,115.03 UV9.M12 ; UV3.M12 186.88,143.9 186.88,143.7 187.34,143.24 187.54,143.24 UV3.L13 ; v1(184.94,126.18) 185.45,126.69 UV1.L12 ; UV7.L13 205.62,134.77 205.62,134.97 206.08,135.42 206.28,135.42 UV7.M12 ; UV5.M12 166.37,143.96 166.37,143.76 166.83,143.31 167.02,143.31 UV5.L13
  BOTTOM w0.305: v1(190,118.55) 189.66,118.89 UV1.Y7 ; UV3.B3 195.19,150.79 v1(195.2,150.79) ; UV9.L11 206.97,114.31 v1(207.37,114.71) ; UV7.N10 v1(208.36,135.91) ; UV5.M1 166.33,152.89 v1(166.33,153.43) ; UV5.L11 167.08,144.85 v1(166.68,145.25) ; v1(215.37,106.76) 215.02,107.11 UV9.B1 ; UV7.C5 211.96,128.31 v1(212.36,127.91) ; UV7.K12 206.36,133.91 v1(205.96,133.51) ; UV5.L2 167.42,152.38 167.42,152.39 v1(167.45,152.43) ; v1(187.95,153.2) 187.6,152.85 UV3.L1 ; v1(168.28,151.65) 168.24,151.6 168.24,151.6 UV5.K3 ; UV7.T14 v1(204.25,138.71) ; v1(213.16,127.1) 213.16,127.11 UV7.B3 ; UV5.G2 170.23,152.05 v1(169.83,151.65) 169.49,151.3 UV5.H3 ; v1(214.74,134.34) 214.7,134.38 214.69,134.38 UV7.L2 ; UV1.G29 172.12,130.15 v1(172.47,130.15) ; UV5.D12 v1(173.08,144.45) ; UV5.H12 169.49,144.04 v1(169.89,143.64) 170.28,143.25 UV5.G13 ; UV6.P2 UV3.D1 193.19,152.79 193.19,153.37 v1(193.25,153.43) ; UV3.L4 187.66,150.45 187.66,150.45 v1(188,150.79) 188.39,151.18 UV3.K3 ; v1(207.56,135.11) 207.16,134.71 UV7.L11 ; UV9.G4 212.55,111.09 212.55,111.07 v1(212.19,110.71) ; UV1.L23 176.46,126.58 v1(176.85,126.19) ; UV9.C5 v1(212.17,107.51) ; UV9.G1 215.26,111.4 v1(215.59,111.4) ; UV9.G2 214.17,111.16 v1(213.77,111.56) 213.42,111.91 UV9.H3 ; UV3.B14 194.8,142.38 194.8,142.37 v1(194.8,141.74) ; UV5.P11 v1(164.28,145.25) ; UV5.C5 v1(173.88,150.05) ; v1(185.94,149.06) 185.94,149.05 185.94,149.53 UV3.N5 ; UV3.E5 192.39,149.58 v1(191.99,149.98) ; UV9.E5 211.77,109.51 v1(212.17,109.91) ; UV1.U11 186.46,121.79 v1(186.88,122.21) ; UV3.N10 v1(186.39,145.98) ; UV7.F3 v1(213.96,130.31) ; UV3.P3 185.19,151.18 v1(184.79,151.58) ; UV9.N10 v1(208.17,115.51) ; UV9.B12 v1(206.57,106.71) ; UV7.H12 206.35,132.31 v1(205.95,131.91) 205.56,131.51 UV7.G13 ; v1(212.97,108.31) 213.37,108.71 UV9.D3 ; UV5.T1 163.08,152.87 162.72,153.24 v1(162.65,153.24) ; v1(214.55,113.94) 214.51,113.98 214.5,113.98 UV9.L2 ; UV9.R5 v1(211.37,117.91) ; v1(185.2,141.82) UV3.P14 UV6.D13 ; UV1.AD11 186.89,115.26 v1(186.89,115.09) ; v1(184.79,144.38) 185.19,143.98 UV3.P12 ; v1(183.16,153.17) 183.23,153.17 183.6,152.8 UV3.T1 ; UV5.M3 v1(165.88,151.65) ; v1(179.63,130.33) 179.19,129.89 UV1.G20 ; UV5.N10 v1(165.88,146.05) ; UV3.D12 v1(193.59,144.38) ; UV9.F3 v1(213.77,109.91) ; UV3.R10 184.8,145.98 v1(184.79,145.98) ; UV9.P12 206.17,116.71 v1(206.57,117.11) ; UV3.G14 190.8,141.74 v1(190.79,141.73) ; UV3.G2 190.75,151.98 v1(190.34,151.58) 190,151.24 UV3.H3 ; UV7.B1 215.21,127.51 v1(215.56,127.16) ; UV7.R5 v1(211.56,138.31) ; UV5.P12 v1(164.28,144.45) ; v1(186.39,151.58) 186.79,151.18 UV3.M3 ; UV3.M1 186.84,152.83 v1(186.84,153.36) ; UV8.P2 UV7.D1 215.16,129.11 215.74,129.11 v1(215.81,129.05) ; UV7.M12 v1(205.96,135.91) ; UV5.T3 163.08,151.25 v1(163.48,150.85) ; v1(208.17,109.91) 207.77,109.51 UV9.E10 ; v1(193.59,150.78) 193.2,151.18 UV3.D3 ; UV5.T12 v1(162.68,143.65) ; UV9.G11 v1(207.37,110.71) ; UV3.T3 v1(183.99,150.78) ; v1(171.11,153.43) 171.09,153.41 UV5.F1 ; UV7.D12 v1(206.76,128.71) ; 189.27,127.91 v1(189.27,127.92) ; 189.27,127.91 189.66,128.29 UV1.J7 ; 189.27,127.91 188.86,127.5 UV1.K8 ; v1(203.93,110.31) UV9.F14 ; UV3.G13 190.79,143.18 v1(190.4,143.57) 190,143.98 UV3.H12 ; v1(184.48,130.08) 184.29,129.89 UV1.G14 ; v1(204.2,137.11) UV7.P14 UV8.D13 ; UV7.G1 215.54,131.51 215.62,131.58 v1(215.68,131.58) ; UV7.G14 204.11,131.51 v1(204.11,131.51) ; v1(174.93,126.4) 174.64,126.69 UV1.L26 ; UV5.B1 174.29,152.9 v1(174.63,153.25) ; UV3.C5 194,149.58 v1(194.39,149.98) ; v1(212.36,130.31) 211.96,129.91 UV7.E5 ; UV9.H12 206.16,111.91 v1(205.76,111.51) 205.37,111.12 UV9.G13 ; UV7.P1 215.73,137.11 v1(215.73,137.11) ; v1(186.85,130.38) 186.36,129.89 UV1.G11 ; v1(180.88,130.14) 181.22,130.14 UV1.G17 ; v1(164.68,141.88) UV5.P14 UV4.D13 ; v1(189.35,124.56) 189.66,124.25 UV1.P7 ; UV1.AJ7 189.96,111.8 189.96,111.57 v1(190.03,111.49) ; v1(187.19,145.18) 187.59,144.78 UV3.L11 ; UV9.P1 v1(215.54,116.71) ; UV9.M14 v1(203.97,115.11) ; v1(215.74,135.46) 215.21,135.46 UV7.M1 ; UV9.D12 v1(206.57,108.31) ; v1(205.95,130.27) 206.36,130.68 UV7.F12 ; UV1.L21 178.53,126.69 v1(178.98,126.24) ; UV9.M12 v1(205.77,115.51) ; UV9.L14 v1(204,114.31) ; UV7.G2 214.36,131.56 v1(213.96,131.96) 213.61,132.31 UV7.H3 ; v1(205.76,109.87) 206.17,110.28 UV9.F12 ; UV3.L2 187.93,152.31 187.93,152.32 v1(187.96,152.36) ; UV3.P1 v1(185.2,153.36) ; v1(181.96,127.1) 182.37,126.69 UV1.L16 ; UV7.B12 206.36,127.51 v1(206.76,127.11) ; v1(173.08,150.85) 172.69,151.25 UV5.D3 ; v1(195.19,144.38) 194.8,143.99 UV3.B12 ; UV5.M12 v1(165.88,143.65) ; UV9.R10 v1(208.17,117.11) ; v1(213.96,135.91) 213.56,135.51 UV7.M3 ; v1(174.69,150.85) 174.68,150.85 UV5.B3 ; UV1.U7 189.66,121.87 v1(189.97,122.18) ; UV5.C10 173.48,145.65 v1(173.08,146.05) ; UV9.F1 215.54,110.31 v1(215.56,110.29) ; UV5.R5 v1(163.48,149.25) ; UV7.D3 213.56,129.11 v1(213.16,128.71) ; v1(208.36,128.71) 207.96,128.31 UV7.C10 ; v1(186.79,141.78) 186.8,141.78 UV3.M14 ; UV3.D11 v1(193.59,145.18) ; UV5.E10 171.88,145.65 v1(171.48,146.05) ; UV4.P2 UV5.D1 172.68,152.85 172.68,153.43 v1(172.74,153.49) ; UV5.N5 165.43,149.6 165.43,149.11 v1(165.43,149.12) ; UV5.M14 v1(166.28,141.85) ; v1(212.97,106.71) 212.97,106.71 UV9.B3 ; v1(172.69,141.88) UV5.D14 ; UV1.AC7 189.66,116.67 v1(189.95,116.38) ; UV1.H10 187.26,129.09 v1(187.66,128.69) 188.06,128.29 UV1.J9 ; UV9.M3 213.37,115.11 v1(213.77,115.51) ; v1(187.65,109.88) 188.05,110.29 UV1.AL9 UV1.AK8 ; UV5.P3 v1(164.28,151.65) ; UV9.C10 207.77,107.91 v1(208.17,108.31) ; UV7.T1 215.18,138.71 215.55,139.08 v1(215.55,139.14) ; UV9.L4 212.64,114.24 212.64,114.24 v1(212.97,113.91) 213.37,113.51 UV9.K3 ; UV3.G11 v1(191.19,145.18) ; v1(167.49,150.85) 167.15,150.52 167.15,150.52 UV5.L4 ; UV1.N11 186.72,124.94 v1(186.72,125.19) 186.72,125.44 UV1.M11 ; v1(189.56,113.96) 189.66,114.05 UV1.AF7 ; UV5.G14 170.29,141.8 v1(170.28,141.8) ; UV1.Y11 186.13,119.35 v1(185.96,119.35) ; v1(204.12,130.71) UV7.F14 ; v1(213.16,134.31) 212.83,134.64 212.83,134.64 UV7.L4 ; v1(212.97,117.11) 212.97,117.11 UV9.P3 ; UV9.N5 211.72,115.96 211.24,115.96 v1(211.24,115.97) ; v1(204.12,127.5) 204.75,127.5 204.76,127.51 UV7.B14 ; UV7.P3 v1(213.16,137.51) ; v1(195.14,153.18) 194.8,152.84 UV3.B1 ; v1(175.04,130.24) 175.03,130.25 174.77,130.25 174.41,129.89 UV1.G26 ; UV5.G1 169.99,153.14 v1(169.99,153.47) ; v1(205.77,113.11) 206.17,113.51 UV9.K12 ; UV5.G11 v1(170.68,145.25) ; UV7.E10 207.96,129.91 v1(208.36,130.31) ; UV9.T3 v1(212.97,118.71) ; v1(215.55,115.06) 215.02,115.06 UV9.M1 ; UV3.F1 191.6,153.35 v1(191.62,153.37) ; UV9.P11 206.97,116.71 v1(207.37,117.11) ; v1(187.6,141.82) UV3.L14 ; v1(190.5,153.4) 190.5,153.08 UV3.G1 ; v1(186.71,124.18) 186.71,123.94 UV1.R11 ; UV7.P12 206.36,137.11 v1(206.76,137.51) ; UV3.F3 v1(191.99,151.58) ; v1(188.79,143.58) 188.4,143.98 UV3.K12 ; UV5.F3 v1(171.48,151.65) ; UV9.T14 v1(203.97,118.31) ; UV10.D13 UV9.P14 v1(204.01,116.71) ; UV3.G4 190.82,150.36 190.84,150.36 v1(191.2,150) ; v1(211.43,136.36) 211.43,136.36 211.91,136.36 UV7.N5 ; UV5.D11 v1(173.08,145.25) ; UV7.K3 213.92,133.55 v1(213.96,133.51) ; v1(204.01,108.71) UV9.D14 ; UV5.E5 171.88,149.65 v1(171.48,150.05) ; UV5.G4 170.31,150.42 170.33,150.42 v1(170.69,150.06) ; UV7.L1 215.23,134.71 v1(215.58,134.36) ; UV5.T14 v1(163.08,141.85) ; v1(191.99,145.98) 192.39,145.58 UV3.E10 ; UV7.M14 204.16,135.51 v1(204.16,135.51) ; v1(191.6,141.75) UV3.F14 ; UV5.B14 174.29,142.45 174.29,142.44 v1(174.29,141.81) ; UV9.L1 215.04,114.31 v1(215.39,113.96) ; UV5.B12 v1(174.68,144.45) ; UV3.R5 v1(183.99,149.18) ; UV7.P11 207.16,137.11 v1(207.56,137.51) ; v1(215.61,108.65) 215.55,108.71 214.97,108.71 UV9.D1 UV10.P2 ; UV1.AG10 187.26,113.01 v1(187.69,112.59) ; UV3.T12 v1(183.19,143.58) ; UV1.K11 UV1.K13 185.06,127.09 UV1.L12 ; v1(215.75,130.69) 215.73,130.71 UV7.F1 ; UV7.T12 v1(205.96,139.11) ; v1(189.26,126.92) 189.26,126.89 UV1.L7 ; UV3.T14 v1(183.6,141.78) ; UV7.R10 208.36,137.51 v1(208.36,137.51) ; UV5.F12 171.11,144.05 v1(171.52,143.64) ; v1(184.79,145.18) 185.19,144.78 UV3.P11 ; v1(167.09,141.88) UV5.L14 ; v1(204.19,134.71) UV7.L14 ; UV5.P1 v1(164.68,153.42) ; UV3.C10 193.99,145.58 v1(193.59,145.98) ; UV3.M12 v1(186.39,143.58) ; v1(192.04,143.57) 191.63,143.98 UV3.F12 ; v1(193.2,141.82) UV3.D14 ; UV5.K12 167.89,144.05 v1(168.28,143.65) ; v1(203.92,111.12) 203.92,111.11 UV9.G14 ; UV9.T12 v1(205.77,118.71) ; UV9.D11 v1(207.37,108.31) ; UV9.B14 204.57,107.11 204.56,107.1 v1(203.93,107.1) ; v1(167.44,153.26) 167.09,152.91 UV5.L1 ; UV7.G4 212.74,131.48 212.74,131.47 v1(212.38,131.1) ; v1(215.36,118.74) 215.36,118.68 214.99,118.31 UV9.T1 ; UV7.T3 v1(213.16,139.11) ; v1(171.09,141.81) UV5.F14 ; UV7.D11 v1(207.56,128.71) ; UV5.R10 163.89,145.65 164.29,146.05 v1(164.28,146.05) ; UV7.G11 v1(207.56,131.11) ; v1(204.2,129.11) UV7.D14
  BOTTOM w0.508: 195.43,155.98 CV356.1 RV40.1 ; RV141.1 v1(196.95,101.49) ; v1(218.02,143.65) 218.34,143.65 218.6,143.39 RV1.1 CV18.1 ; RV14.1 CV30.1 211.73,98.57 v1(211.87,98.44) ; v1(190.66,138.5) 190.28,138.12 CV350.1 RV193.1 ; RV140.1 162.02,130.64 RV139.1 162.84,130.63 v1(163.99,129.49) ; v1(200.94,130.31) 200.5,130.76 CV21.1 RV6.1 ; RV19.1 CV34.1 200.31,114.81 v1(200.69,115.19) ; v1(204.44,144.79) CV137.1 ; CV32.1 203.48,100.66 v1(203.99,100.15) 204.37,100.53 RV16.1 ; RV142.1 v1(197.96,102.56) ; RV183.1 CV328.1 171.07,138.19 v1(171.43,137.82) ; CV295.1 CV296.1 217.05,122.86 v1(216.88,122.69)
  vias: v1(167.42,155.53) v1(167.42,154.95) v1(168.05,155.53) v1(168.05,154.95) v1(168.69,155.53) v1(168.69,154.95) v1(169.32,155.53) v1(169.32,154.95) v1(187.74,155.28) v1(187.74,154.7) v1(188.37,155.28) v1(188.37,154.7) v1(189.01,155.28) v1(189.01,154.7) v1(189.64,155.28) v1(189.64,154.7) v1(212.19,151.01) v1(212.19,150.37) v1(212.83,151.01) v1(212.83,150.37) v1(216.11,113.74) v1(216.11,113.1) v1(216.11,112.47) v1(216.11,111.83) v1(216.3,134.12) v1(216.3,133.49) v1(216.3,132.85) v1(216.3,132.22) v1(216.75,113.74) v1(216.75,113.1) v1(216.75,112.47) v1(216.75,111.83) v1(216.88,134.12) v1(216.88,133.49) v1(216.88,132.85) v1(216.88,132.22) v4(157.94,154.64)
