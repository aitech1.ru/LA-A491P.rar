# Allegro board LAA491PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35VGPUP: length 12.9
  TOP w0.102: v1(183.48,165.81) v2(183.48,165.29)
  IN3 w0.254: v1(183.48,165.81) 189.51,165.81 189.89,166.19 v1(189.89,171.08)
  BOTTOM w0.254: PR1107.2 v1(189.89,171.08)
+1.35VP: length 25.3
  TOP w0.102: v3(160.31,27.52) v2(160.9,27.52)
  IN2 w0.203: v3(145.96,26.31) 146.4,26.76 159.1,26.76 159.87,27.52 v3(160.31,27.52)
  IN2 w0.762: 154.72,25.35 148.37,25.35
  BOTTOM w0.203: 159.8,27.26 159.31,26.77 PU200.5 ; PU200.19 156.13,25.23 v1(155.99,25.36)
  BOTTOM w0.254: 159.8,27.26 160.06,27.52 v3(160.31,27.52) 160.55,27.76 PR207.2
  vias: v1(155.99,25.94) v3(146.97,25.11) v3(147.61,25.11) v3(147.92,27.38) v3(148.56,27.38) v3(149.19,27.38) v3(149.83,27.38) v3(150.46,27.38) v3(151.1,27.38)
+1.35VS_VGA: length 0.7
  TOP w0.102: v1(185.51,161.64) v4(185.51,162.33)
  vias: v1(181.19,160.35) v1(181.51,160.86) v1(181.83,160.35) v1(182.15,160.86) v1(182.46,160.35) v1(182.78,160.86) v1(183.1,160.35) v1(183.42,160.86) v1(183.73,160.35) v1(184.05,160.86) v1(184.88,161.64) v1(184.88,161.03) v1(185.51,161.03) v1(187.1,160.28) v1(187.42,160.79) v1(187.74,160.28) v1(188.05,160.79) v1(215.61,150.82) v1(215.61,150.19) v1(216.25,150.82) v1(216.25,150.19)
+3V_WLAN:
  vias: v1(92.8,148.93) v1(92.8,148.35) v1(92.8,147.76) v1(105.5,146.82) v1(106.09,146.82) v1(106.67,146.82) v1(117.19,149.49) v1(117.77,149.49) v1(118.36,149.49) v1(118.94,149.49) v2(92.79,146.6)
+3VALW: length 592.4
  TOP w0.203: UE1.9 186.39,34.6 186.27,34.49 185.64,34.49 185.49,34.34 CE6.2 ; v1(182.59,52.14) 183.1,52.14 183.19,52.06 UE1.96 ; CE5.2 180.4,38.51 UE1.125 ; CE2.1 191.59,33.78 UE1.22 ; UG1.2 71.03,40.14 70.78,39.89 ; UE1.33 198.06,37.31 v1(198.47,36.9)
  TOP w0.254: CG10.1 70.23,39.34 70.78,39.89
  TOP w0.508: v1(47.13,86.45) 47.13,88.08 45.34,89.87 JPWR.1 ; v1(190.86,33.74) CE2.1 ; PR28.1 128.38,165.95 127.85,165.43 v1(127.41,165.43) ; v1(69.55,39) CG10.1 ; v1(182.59,52.14) 181.96,52.78 181.96,54.82 176.61,60.16 176.61,63.68 175.72,64.56 175.72,71.55 175.39,71.88 175.39,78.97 v4(172.77,81.58) v1(170.02,84.34) ; RE71.1 177.77,42.57 176.99,43.34 v1(176.99,43.69) ; 194.47,57.03 190.95,57.03 189.92,56 ; RE11.2 182.3,32.29 186.03,32.29 186.22,32.49 186.22,33.36 186.53,33.67 v1(186.53,33.74) 186.43,33.84 CE6.2 ; v1(135.16,184.92) 134.37,184.92 133.67,185.62 PR3.2 ; v1(179.43,36.7) CE5.2
  TOP w1.016: 47.46,29.03 47.46,43.63 36.99,54.11 36.99,72.02 42.32,77.35 44.86,77.35 46.19,78.69 46.19,80.53
  TOP w1.524: 204.75,51 200.89,51 198.78,53.11 198.78,54.62
  IN2 w0.508: 176.92,43.69 v1(176.99,43.69) ; 176.92,43.69 176.69,43.91 176.69,45.67 182.59,51.58 v1(182.59,52.14) ; 176.92,43.69 176.85,43.69 174.27,41.11 v1(174.27,37.16) 174.27,29.35 172.34,27.42 172.34,25.12 v1(171.9,24.67) ; v1(201.32,150.94) 201.27,150.94 195.86,156.35 177,156.35 171.8,161.55 171.8,179.88 v1(175.7,183.78)
  IN2 w1.016: 211.87,89.42 217.52,89.42 219.8,87.13 219.8,60.08 213.1,53.38 210.88,53.38 208.56,51.06
  IN2 w2.032: 197.45,23.19 197.45,28.08 199.14,29.76 201.26,29.76 202.53,31.03 202.53,33.6 205.13,36.21 205.13,41.79 204.94,41.98 204.94,41.99 203.23,43.7 203.23,49.1 204.5,50.37
  IN3 w0.254: v1(135.16,184.92) 135.35,185.11 151.86,185.11 154.59,182.38 174.3,182.38 v1(175.7,183.78)
  IN3 w0.508: v1(201.32,150.94) 201.32,150.45 203.73,148.05 203.73,143.33 204.54,142.52 214.7,142.52 217.49,139.74 217.49,125.64 216.25,124.4 216.25,121.02 217.37,119.9 217.37,106.27 211.99,100.89 211.99,99.58 210.72,98.31 210.72,95.07 211.55,94.24 211.55,92.21 212.17,91.59 v1(212.17,90.43) ; v1(174.27,37.16) 174.27,36.99 174.58,36.69 179.42,36.69 v1(179.43,36.7) 179.65,36.48 182.44,36.48 183.15,35.77 184.5,35.77 v1(186.53,33.74) 186.92,33.74 188.18,35 189.6,35 v1(190.86,33.74) 191.61,34.49 193.51,34.49 194.24,33.77 195.98,33.77 196.41,34.2 196.41,34.85 v1(198.47,36.9) ; v1(47.82,27.89) 50.39,27.89 59.73,37.22 67.77,37.22 v1(69.55,39) ; v1(127.41,165.43) 127.41,163.45 128.98,161.88 128.98,160.29 129.5,159.78 144.11,159.78 144.49,159.4 v1(144.49,158.32) ; v1(195.29,57.22) 194.53,57.22 193.51,56.21 190.66,56.21 189.07,54.62 189.07,52.4 188.46,51.79 182.95,51.79 v1(182.59,52.14)
  IN3 w1.016: 46.83,87.37 46.83,93.28 42.57,97.53 42.57,101.22
  BOTTOM w0.254: PU1200.7 177.28,182.87 PC1205.1 v1(175.7,183.78)
  BOTTOM w0.508: v1(127.41,165.43) 127.41,174.25 127.92,174.76 132.43,174.76 134.97,177.3 134.97,184.73 v1(135.16,184.92) PR16.2 ; v1(170.02,84.34) 170.02,90.75 171.85,92.59 RV109.1
  vias: v1(42.07,102.33) v1(42.7,102.33) v1(46.32,82.56) v1(46.32,81.98) v1(46.54,86.22) v1(47.2,27.89) v1(94.25,29.28) v1(94.25,28.7) v1(94.25,28.12) v1(94.25,27.53) v1(94.83,29.28) v1(94.83,28.7) v1(94.83,28.12) v1(94.83,27.53) v1(195.74,56.78) v1(196.24,56.33) v1(197.34,21.85) v1(197.34,21.22) v1(198.02,21.85) v1(198.02,21.22) v1(206.47,51.32) v1(206.47,50.68) v1(207.1,51.32) v1(207.1,50.68) v1(211.48,90.43) v3(105.76,19.89) v3(106.39,19.89) v3(107.03,19.89) v3(107.73,19.89) v3(108.36,19.89) v3(132.93,11.88) v3(133.95,11.88) v3(134.97,11.88) v3(135.98,11.88) v3(136.87,12.65) v3(137.38,11.88) v3(137.89,12.65) v3(138.84,11.82) v3(139.86,11.82) v3(140.87,11.82) v3(141.89,11.82) v4(140.96,15.56) v4(197.48,56.42)
+3VALW_PCH: length 286.2
  TOP w0.254: v1(119.61,112.41) 119.29,112.41 118.42,111.54 118.05,111.54 117.92,111.67 C75.2
  TOP w0.508: C78.1 122.45,113.74 v1(122.24,113.95) ; v1(123.32,99.05) 123.21,98.93 RC127.1 123.63,98.19 124.74,97.08 124.74,95.85 126.64,93.96 126.64,92.45 127.47,91.62 151.13,91.62 152.95,89.8 163.3,89.8 163.91,90.41 v1(163.91,90.42) ; C81.1 125.07,109.75 v1(125.11,109.71) ; v1(151.29,100.02) 151.29,103.91 150.97,104.23 R264.1
  TOP w1.016: 140.36,29.54 140.36,33.09 136.05,37.41 125.63,37.41 122.2,40.84 122.2,50.24
  IN1 w0.381: v1(119.61,112.41) 120.7,112.41 v1(122.24,113.95)
  IN2 w0.508: 123.32,102.64 122.27,102.64 120.74,104.16 120.74,109.62 120.35,110.02 120.35,112 119.93,112.41 v1(119.61,112.41) ; 123.32,102.64 v1(123.32,99.05) 123.33,99.03 123.33,96.9 112.42,85.99 65.82,85.99 v1(64.55,87.26) ; 123.32,102.64 124.26,103.58 124.26,108.86 v1(125.11,109.71)
  BOTTOM w0.254: 124.51,114 125.23,114 UC1.AA9 UC1.AC9 ; v1(125.11,109.71) 124.95,109.87 124.85,109.87 UC1.AH10 ; v1(119.61,112.41) 119.57,112.41 119.2,112.04 UC1.AE20 119,112.04 UC1.AE21
  BOTTOM w0.381: RC120.1 146.11,112.87 145.52,113.46 145.29,113.46 144.38,114.37 RC32.1 ; v1(122.24,113.95) 124.46,113.95 124.51,114
  BOTTOM w0.406: v1(149.27,114.53) QH1.2 QH1.5
  BOTTOM w0.508: RC64.2 64.03,87.77 v1(64.55,87.26) ; R2330.1 135.92,104.29 135.92,105.85 v1(135.98,105.91) 136.74,106.67 136.74,106.75 138.52,108.53 138.78,108.53
  BOTTOM w1.016: 163.35,87.07 163.35,86.69 160.6,83.93 121.71,83.93 115.45,77.67 115.45,56.13 116.53,55.04 116.53,52.95 117.3,52.18 122.43,52.18 122.52,52.27
  vias: v1(121.95,51.32) v1(122.58,51.32) v1(131.95,110.84) v1(132.54,110.84) v1(146.71,111.9) v1(147.3,111.9) v1(147.54,105.04) v1(148.17,105.04) v1(150.61,113.8) v1(150.61,113.22) v1(156.05,92.85) v1(156.49,92.4) v1(161.45,92.97) v1(161.89,92.53) v4(150.32,96.16)
+3VALW_PCH_GATE: length 4
  TOP w0.203: U2304.3 v1(141.55,21.35)
  BOTTOM w0.102: v2(141.85,18.58) 142.13,18.87 R416.2
  BOTTOM w0.508: v1(141.55,21.35) 142.16,20.74 C2314.1 142.13,20.66 R416.2
+3VALWP: length 12
  TOP w0.508: v1(129.82,11.38) PC102.1 PR109.1
  IN3 w0.254: v1(129.82,11.38) 129.82,11.82 131.03,13.03 133.51,13.03 137.44,16.96 v3(137.63,16.96)
  vias: v2(140.86,16.17)
+3VGS: length 259.8
  TOP w0.381: QV15.5 QV15.2 177.89,95.38 v1(178.21,95.7)
  TOP w0.508: v1(190.86,102.9) 189.64,101.68 v1(189.64,97.16) 189,96.52 186.53,96.52 ; RV91.1 173.25,92.54 172.77,93.02 v1(172.77,93.46) ; RV199.1 183.03,94.36 v1(183.48,94.81) ; QV28.2 184.13,94.76 v1(184.15,94.78) ; v1(214.6,59.51) 214.6,58.56 213.39,57.35 210.09,57.35 209.64,57.8 PR828.1 ; v1(179.92,92.71) RV90.1
  IN1 w0.508: v1(162.98,108.96) 162.98,109.93 163.53,110.49 163.53,113.04 165.57,115.08 165.57,116 166.94,117.36 167.29,117.36 167.62,117.69 167.62,118.86 166.3,120.18 162.81,120.18 158.46,124.53 156.08,124.53 155.29,125.32 155.29,127.2 156.68,128.6 156.68,133.23 160.09,136.64 160.09,150.72 158.6,152.21 158.6,152.27 157.13,153.74 v1(157.13,154.71)
  IN2 w0.508: v1(157.13,154.71) 162.33,159.9 168.3,159.9 170.91,162.51 170.91,181.24 169.35,182.8 169.35,183.5 v1(170.02,184.17)
  IN3 w0.508: v1(175.03,114.18) 174.66,114.18 174.34,114.49 170.71,114.49 169.83,113.6 169.06,113.6 168.43,112.97 166.78,112.97 166.08,112.27 166.08,111.73 165.44,111.1 164.75,111.1 164.34,110.69 164.34,109.32 163.97,108.96 v1(162.98,108.96) ; v1(190.86,102.9) 190.86,102.1 191.78,101.18 194.77,101.18 196.31,99.64 196.31,95.77 201.39,90.69 208.33,90.69 209.41,89.61 211.61,89.61 216.25,84.97 216.25,77.69 218.17,75.77 218.17,61.54 216.96,60.34 215.42,60.34 v1(214.6,59.51) ; v1(179.39,102.94) 179.39,104.18 179.03,104.53 179.03,107.57 179.29,107.83 179.29,109.96 178.81,110.45 178.81,111.61 177,113.41 v1(177,114.24)
  BOTTOM w0.381: UV14.1 178.55,95.36 v1(178.21,95.7) ; UV13.5 161.27,109.09 161.59,108.77 CV326.2
  BOTTOM w0.508: v1(214.6,59.51) PR826.1 PR835.1 PR837.1 PR839.1 ; PR1213.1 v1(170.02,184.17) ; v1(157.13,154.71) 157.76,154.71 162.2,159.14 173.7,159.14 174.35,158.49 RV105.1 ; v1(172.77,93.46) 172.77,93.89 173.45,94.57 RV98.2 175.53,94.59 v1(176,95.07) 175.63,95.43 RV96.2 ; RV74.1 189.97,97.49 v1(189.64,97.16) ; v1(184.15,94.78) QV22.1 ; RV235.1 175.92,101.12 v1(176.6,100.45) ; CV102.1 180.94,93.03 v1(181.13,92.84) ; CV326.2 162.79,108.77 v1(162.98,108.96) ; CV85.2 179.86,92.78 v1(179.92,92.71) ; v1(190.86,102.9) RV73.1
  vias: v1(183.45,95.99) v1(184.09,95.99) v1(184.72,95.99) v1(185.36,95.99) v1(185.99,95.99) v4(180.48,98.44)
+3VLP: length 262.4
  TOP w0.203: v1(127.82,13.68) 127.83,13.69 PU100.3 ; CG4.1 70.32,43.38 70.63,43.07 UG1.15 ; v1(180.14,44.43) 180.39,44.43 180.72,44.11 UE1.111
  TOP w0.508: PC109.1 v1(127.82,13.68) ; RE49.2 193.26,27.57 190.59,30.23 181.43,30.23 179.04,32.63 179.04,34.5 v4(178.08,35.46) 173.97,39.57 170.32,39.57 167.99,41.9 v1(167.99,43.77) ; v1(68.94,44.07) CG4.1
  IN1 w0.508: v1(171.32,21.16) 171.32,14.08 167.35,10.11 150.46,10.11 148.43,12.14 143.67,12.14 142.52,13.28 128.21,13.28 v1(127.82,13.68)
  IN2 w0.508: v1(171.32,21.16) 169.64,22.84 169.64,40.27 167.99,41.92 v1(167.99,43.77)
  IN3 w0.508: v1(180.14,44.43) 179.45,44.43 179.23,44.21 177.59,44.21 177.17,44.63 171.86,44.63 170.95,43.71 168.04,43.71 v1(167.99,43.77) 118.5,43.77 118.1,44.17 69.04,44.17 v1(68.94,44.07)
  BOTTOM w0.508: 200.31,13.92 199.36,13.92 197.45,15.82 183.02,15.82 181.3,17.55 176.42,17.55 172.81,21.16 v1(171.32,21.16)
+3VS: length 342.6
  TOP w0.203: UA1.1 30.61,18.45 30.69,18.37 31.69,18.37 CA58.1 ; v1(23.14,18.3) 23.29,18.45 UA1.36 ; UA1.9 31.43,21.65 CA60.1
  TOP w0.254: UR1.4 177.32,19.06 177.63,18.76 177.96,18.76
  TOP w0.406: CC11.1 149.31,103.2 v1(148.81,103.2) 148.25,103.75 UC3.5
  TOP w0.508: RS7.1 215.65,57.63 v1(215.65,57.2) ; CA60.1 32.15,22.79 32.22,22.87 CA59.1 31.84,23.44 31.59,23.7 v1(31.33,23.7) ; v1(34.26,18.18) 34.26,18.17 34.51,17.92 34.51,16.33 34.15,15.97 32.46,15.97 32.1,16.33 CA57.1 32.1,17.97 CA58.1 ; v1(122.48,118.68) 122.19,118.68 121.9,118.39 C71.1 ; RA9.1 24.78,14.32 v1(25.02,14.08) ; RE10.1 RE9.1 v1(187.04,55.64) ; RC128.1 123.5,97.31 124.08,96.72 124.08,95.67 125.95,93.8 v1(125.95,92.87) ; R24.2 v1(22.38,108.14) ; v1(32.99,26.43) 32.99,27.51 32.21,28.28 RA1.1 ; PR1110.1 191.74,169.68 192.1,170.04 192.1,184.2 v1(193.07,185.18) ; RL33.1 43.64,85.79 v1(43.65,85.8)
  TOP w1.524: 184.37,88.97 183.73,88.97 177.54,82.78 177.54,72.73 179.07,71.19 180.5,71.19 ; 55.27,19.5 55.27,37.79
  IN1 w0.508: v1(25.02,14.08) 25.02,15.03 23.14,16.91 v1(23.14,18.3) 24.35,18.3 25.11,19.06 26.25,19.06 27.08,19.89 29.68,19.89 30.83,18.74 33.7,18.74 33.85,18.59 33.87,18.59 34.23,18.23 34.23,18.21 v1(34.26,18.18) ; v1(124.16,116.31) 124.03,116.19 123.4,116.19 123.07,116.52 123.07,118.37 122.75,118.68 v1(122.48,118.68) ; v1(22.38,108.14) 22.38,105.34 23,104.73 23,98.09 22.63,97.72
  IN1 w1.016: 55.46,17.03 56.16,16.33 65.24,16.33
  IN2 w0.508: v1(16.26,26.19) 16.93,26.86 20.73,26.86 21.66,25.92 v1(21.86,25.92) 21.86,26.17 24.76,29.07 31.42,29.07 32.99,27.51 v1(32.99,26.43)
  IN2 w1.524: 105.25,70.05 105.25,70.05 107.79,70.05 109.57,68.27 109.57,53.1
  IN2 w2.032: 219.08,141.46 219.08,120.7 218.81,120.43 218.81,116.96 219.08,116.69 219.08,111.37 217.64,109.93 217.64,105.93 212.69,100.98 212.69,99.83
  IN3 w0.508: v1(92.23,137.34) 91.62,137.34 91.34,137.61 91.34,138.95 91.79,139.39 v1(92.1,139.39)
  BOTTOM w0.203: C92.1 20.54,97.92 20.54,98.84 20.45,98.93 U4.51 ; PU501.21 92.11,137.22 v1(92.23,137.34) 92.03,137.54 91.86,137.54 91.79,137.62 PU501.20
  BOTTOM w0.254: UC1.U8 125.61,116.37 125.25,116.73 UC1.T9 124.62,116.84 124.16,116.38 v1(124.16,116.31) ; v1(122.48,118.68) 122.44,118.73 UC1.K14 UC1.K16 ; UC4.14 70.6,106.98 70.27,107.32 CC13.1 ; v1(131.25,131.87) 130.95,131.58 RP51.8 ; UC1.V8 125.66,115.41 125.25,115 UC1.W9 v1(125.87,114.94) 125.87,114.64 UC1.Y8 ; RP51.6 v1(129.95,131.87)
  BOTTOM w0.356: v1(182.59,69.5) 182.15,69.94 JDIMM2.199
  BOTTOM w0.381: v1(16.03,114.81) Q2.2
  BOTTOM w0.406: Q2.5 v1(16.03,114.81)
  BOTTOM w0.432: QC1.5 v1(145.39,108.89) QC1.2
  BOTTOM w0.508: C92.1 v1(21.36,97.74) ; v1(158.59,102.9) 158.59,93.36 161.51,90.43 161.51,86.12 160.88,85.48 C2327.1 159.35,85.5 U2302.8 ; PR842.2 PR808.1 209.91,53.68 v1(209.77,53.54) ; v1(114.72,54.43) 113.71,55.44 113.71,79.1 124.11,89.5 124.11,91.03 v1(125.95,92.87) 125.45,93.37 RC3.1 ; R2331.1 147.93,109.9 R2332.1 ; RL37.2 37.68,89.6 v1(37.43,89.85) ; v1(142.84,118.46) 142.84,117.93 142.55,117.63 R2335.1 R2334.1 ; R2332.1 147.93,110.65 147.37,111.21 146.07,111.21 RC107.2 ; R2332.1 148.43,110.06 148.62,110.25 v1(148.62,110.63) ; v1(62.51,103.39) 62.11,103.8 60.95,103.8 60.66,103.51 60.66,102.9 60.99,102.57 RC362.1 ; RC75.1 v1(131.04,135.66) ; RA7.1 16.69,25.75 v1(16.26,26.19) ; PR308.1 v1(149.77,151.01) ; RA2.1 21.84,25.94 v1(21.86,25.92) ; v1(26.13,97.34) 25.61,96.82 R35.1 ; v1(13.81,100.07) R41.1 ; 34.95,23.89 34.95,18.88 v1(34.26,18.18) ; v1(52.3,104.99) 52.06,105.23 RE50.1 ; RC121.1 136.5,113.56 v1(136.49,113.55) ; v1(14.43,96.66) R18.1
  vias: v1(17.68,118.26) v1(17.68,117.68) v1(19.42,114.22) v1(19.42,113.64) v1(25.26,113.03) v1(25.85,113.03) v1(33.68,95.21) v1(33.68,94.63) v1(53.97,17.7) v1(53.97,17.09) v1(54.58,17.7) v1(54.58,17.09) v1(55.01,39.84) v1(55.01,39.25) v1(55.59,39.84) v1(55.59,39.25) v1(66.07,108.31) v1(66.2,16.39) v1(66.2,15.78) v1(66.66,108.31) v1(66.81,16.39) v1(66.81,15.78) v1(67.24,108.31) v1(84.23,136.59) v1(84.66,136.07) v1(84.81,136.64) v1(85.4,39.9) v1(85.4,39.32) v1(85.98,39.9) v1(85.98,39.32) v1(86.57,39.9) v1(86.57,39.32) v1(87.15,39.9) v1(87.15,39.32) v1(87.74,39.9) v1(87.74,39.32) v1(88.32,39.9) v1(88.32,39.32) v1(100.11,150.25) v1(100.74,150.25) v1(101.38,150.25) v1(103.47,69.85) v1(104.04,70.05) v1(104.04,69.46) v1(108.93,51.41) v1(109.52,51.41) v1(110.1,51.41) v1(120.67,149.87) v1(120.67,149.29) v1(121.25,149.87) v1(121.25,149.29) v1(126.96,132.83) v1(127.71,132.8) v1(137.44,122.18) v1(138.01,122.18) v1(138.65,122.18) v1(141,114.31) v1(177.28,55.48) v1(177.28,54.9) v1(177.28,54.28) v1(178.21,19.38) v1(178.79,19.38) v1(179.38,19.38) v1(182.59,68.86) v1(182.59,68.23) v1(184.1,91.32) v1(184.37,90.75) v1(184.69,91.32) v1(201.3,164.87) v1(201.3,164.28) v1(201.87,164.6) v1(211.41,96.94) v1(211.41,96.35) v1(211.99,96.94) v1(211.99,96.35) v1(217.02,175.09) v1(217.02,174.51) v1(217.61,175.09) v1(217.61,174.51) v1(218.39,53.24) v1(218.39,52.65) v1(218.39,52.07) v1(220.68,143.61) v1(220.68,143.02) v1(221.26,143.61) v1(221.26,143.02) v4(135.27,123.96)
+3VS_6511: length 37.9
  TOP w0.508: C20.1 18.9,108.72 18.9,107.81 v1(18.61,107.52)
  IN1 w0.508: v1(16.46,98.17) 16.46,98.85 18.61,101 v1(18.61,107.52) 18.9,107.81 18.9,109.4 18.63,109.66 18.63,110.93 19.46,111.76 v1(19.46,112.58)
  IN3 w0.508: v1(16.46,98.17) 17.52,97.11 23.8,97.11 24.29,97.6 24.29,98.42 v1(24.04,98.66)
  BOTTOM w0.127: 19.47,112.57 18.8,111.9 v2(18.8,111.76)
  BOTTOM w0.203: C21.1 24.22,97.78 23.51,98.49 22.99,98.49 22.45,99.03 U4.46 ; U4.16 18.85,106.99 18.62,107.21 18.62,107.51 v1(18.61,107.52) ; U4.54 19.25,99.02 18.59,98.36 17.8,98.36 C22.1
  BOTTOM w0.508: C22.1 16.89,97.74 v1(16.46,98.17) ; v1(24.04,98.66) 24.44,98.27 24.44,97.83 C21.1
+3VS_CAM: length 4.2
  TOP w0.127: RX27.2 219.04,173.42 220.04,172.42 v4(220.42,172.42)
  TOP w0.508: v1(218.45,174.49) 218.49,174.49 219.04,173.94 RX27.2
  BOTTOM w0.254: v1(218.45,174.49) JLVDS.29
+3VS_RT: length 24.5
  TOP w0.432: v1(193.45,158.51) v4(193.45,159.97) 193.45,163.46 193.77,163.78 QX6.5 ; QX6.2 196.75,163.78 v1(196.82,163.71)
  TOP w0.508: RX30.1 196.71,172.53 197.39,173.2 v1(197.39,173.47) 197.39,173.71 196.88,174.22 196.88,177.24 197.64,178 v1(197.64,179.33) ; LX7.2 207.48,161.24 v1(208.12,160.6)
  BOTTOM w0.381: CX10.1 213.39,161.22 UX2.5
  BOTTOM w0.508: RX168.1 v1(197.64,179.33) ; v1(213.31,160.41) 213.57,160.67 CX10.1 ; RX4.2 200.35,167 v1(200.27,167.08) 199.25,167.08 LX8.2 ; v1(197.39,173.47) 197.39,173.86 RX169.1
+5V_HDD:
  vias: v2(223.6,62.36)
+5V_PVDD: length 12.2
  TOP w0.203: UA1.41 26.48,16.76 v1(26.56,16.68) ; UA1.46 28.48,16.64 28.75,16.38 v1(28.75,15.76)
  TOP w0.508: RV54.2 CA55.1 31.33,14.98 CA56.1 v2(29.9,15.06) 29.2,15.76 v1(28.75,15.76)
  BOTTOM w0.508: v1(26.56,16.68) 26.83,16.94 CA54.1 26.84,17.47 CA53.1 27.91,17.29 28.73,16.46 28.73,16.2 28.75,16.19 v1(28.75,15.76)
+5V_USB_PWR1:
  vias: v1(18.62,65.76) v1(18.62,65.12) v1(19.26,65.76) v1(19.26,65.12) v4(18.99,63.93)
+5V_USB_PWR2:
  vias: v1(23.33,51.51) v1(23.33,50.87) v1(23.97,51.51) v1(23.97,50.87) v4(22.47,51.12)
+5V_USB_PWR3:
  vias: v1(14.19,31.32) v1(14.19,30.73) v1(14.77,31.32) v1(14.77,30.73) v4(14.09,32)
+5V_USB_PWR4: length 4.8
  TOP w0.102: JDB.3 208.8,47.7 v4(208.78,47.72)
  IN2 w2.032: 210.79,48.33 209.83,47.38 208.25,47.38
  vias: v1(204.88,47.64) v1(205.52,47.64) v1(206.15,47.64) v1(206.79,47.64) v1(212.37,49.79) v1(212.37,49.16) v1(213.01,49.79) v1(213.01,49.16)
+5VA: length 6.1
  TOP w0.102: 22.33,23.68 v2(22.94,24.29)
  TOP w0.203: UA1.26 23.61,22.45 22.39,23.66 22.39,23.68 CA51.1
  TOP w0.508: RV59.2 20.22,24.39 CA71.1 21.86,23.76 CA51.1
+5VALW: length 401.8
  TOP w0.254: v1(186.59,175.21) 184.88,175.21 184.43,174.76 184.43,174 183.67,173.24 PC1105.1 183.93,172.79 PU1100.7
  TOP w0.508: PR824.1 200.49,60.67 200.03,60.21 v1(200.03,59.83) ; RD46.1 58.97,13.9 v1(59.41,14.35) ; R10.1 85.53,24.72 84.8,23.99 v1(84.8,23.44) ; v1(29.01,11.49) LED1.2 ; PR8.1 135.61,186.07 140.43,186.07 141.44,187.08 146.63,187.08 147.48,186.23 149.77,186.23 150.19,186.23 v4(152.87,183.55) 154.47,181.95 159.47,181.95 159.81,181.62 159.81,181.62 160.63,180.84 161.59,180.23 162.46,179.89 164.12,178.23 172.64,178.23 173.26,177.62 v1(173.26,176.79) ; R2347.1 v1(41.13,63.82) ; LED3.1 v1(46.9,11.5) ; LED4.2 v1(56.01,11.5)
  IN1 w0.508: v1(186.59,175.21) 185.68,176.12 173.93,176.12 v1(173.26,176.79)
  IN2 w0.508: v1(200.03,59.83) 199.71,59.83 198.66,58.77 198.66,51.25 201.01,48.91 201.01,43.95 v1(203.55,41.41) ; v1(212.88,40.97) 212.88,43.51 215.61,46.24 215.61,53.39 221.45,59.23 221.45,82.24 224.36,85.14 224.36,96.53 224.9,97.07 224.9,109.13 223.49,110.55 223.49,123.56 223.75,123.82 224.39,124.46 224.39,145.64 215.33,154.69 215.33,162.04 211.05,166.32 207.01,166.32 206.07,167.26 202.51,167.26 201.67,166.42 199.08,166.42 190.29,175.21 v1(186.59,175.21) ; v1(27.83,61.8) 27.83,62.71 29.43,64.31 32.13,64.31 v1(32.16,64.29) 40.66,64.29 v1(41.13,63.82)
  IN3 w0.508: v1(188.43,91.2) 188.43,82.93 192.02,79.34 192.02,66.89 193.56,65.35 198.72,65.35 200.03,64.04 v1(200.03,59.83) ; v1(32.16,64.29) 32.16,86.29 36.73,90.87 36.73,102.32 v1(40.15,105.74)
  BOTTOM w0.203: PU200.12 158.91,22.8 159.31,22.4 v3(159.31,22.2) 159.31,22.11 159.67,21.74 PC204.2
  BOTTOM w0.508: 206.02,41.67 203.8,41.67 v1(203.55,41.41) ; v1(84.8,23.44) 84.81,23.45 96.22,23.45 97.78,25.01 v1(97.78,26.29) ; v1(188.43,91.2) 189.26,92.02 RV107.1 ; PU1000.6 40.03,106.63 PC1001.1 v1(40.15,105.74) ; PR206.1 v1(162.09,22.24) ; PR814.2 205.14,63.88 201.88,63.88 200.03,62.03 v1(200.03,59.83) 200.03,58.77 PR822.2 ; v1(212.88,40.97) 212.18,41.67 207.42,41.67
  vias: v1(22.13,30.3) v1(22.13,29.72) v1(22.71,30.3) v1(22.71,29.72) v1(27.83,61.19) v1(27.82,60.59) v1(27.82,60.01) v1(29.81,54.56) v1(29.81,53.92) v1(30.45,54.56) v1(30.45,53.92) v1(97.78,27) v1(98.43,27) v1(98.43,26.29) v1(99.01,27) v1(99.01,26.29) v1(99.6,27) v1(99.6,26.29) v1(160.87,22.83) v1(160.87,22.24) v1(161.45,22.83) v1(161.45,22.24) v1(205.13,33.73) v1(205.13,33.09) v1(205.77,33.73) v1(205.77,33.09) v1(206.98,40.78) v1(206.98,40.19) v1(207.56,40.78) v1(207.56,40.19) v3(115.47,11.82) v3(115.47,10.81) v3(116.49,11.82) v3(116.49,10.81) v3(117.5,11.82) v3(117.5,10.81) v3(118.52,11.82) v3(118.52,10.81) v3(119.54,11.82) v3(119.54,10.81) v3(120.55,11.82) v3(120.55,10.81) v3(144.36,10.87) v3(144.36,10.23) v3(145,10.87) v3(145,10.23) v3(145.63,10.87) v3(145.63,10.23) v3(146.27,10.87) v3(146.27,10.23) v3(146.9,10.87) v3(146.9,10.23) v3(147.54,10.87) v3(147.54,10.23) v3(165,11.63) v3(165,11) v3(165.64,11.63) v3(165.64,11) v3(166.27,11.63) v3(166.27,11) v4(163.72,21.73) v4(205.44,35.96)
+5VALWP: length 26.6
  TOP w0.203: v3(127,19.28) 127,18.99 127.43,18.56 PU100.14
  TOP w0.508: v3(126.67,11.33) 126.71,11.37 PR104.2
  IN2 w0.254: v3(118.52,16.42) 118.53,16.42 120.48,14.48 124.98,14.48 126.65,12.8 126.65,11.36 v3(126.67,11.33)
  IN2 w0.508: v3(119.03,16.87) 120.92,14.97 125.3,14.97 126.78,16.45 126.78,16.86 127.09,17.18 127.09,18.75 127,18.84 v3(127,19.28)
  BOTTOM w0.508: v3(126.67,11.33) PC108.2
  vias: v2(115.66,16.12)
+5VS: length 251.2
  TOP w0.508: v1(43.74,116.69) Q1.2
  TOP w1.016: 42.13,29.73 v2(42.13,23.44) 42.13,20.27 36.99,15.12 36.99,12.84 37.37,12.46 ; 32.03,96.52 33.18,96.52 37.18,100.52 42.19,100.52 43.79,102.12 44.99,102.12
  IN1 w1.016: 36.86,11 33.24,11 ; 41.11,30.93 39.02,30.93 38.76,31.19 24.35,31.19 23.71,31.82 20.41,31.82 19.03,30.44 19.03,26.57
  IN2 w0.508: v1(46.51,102.12) 49.24,102.12 54.96,96.4 84.8,96.4 91.79,103.39 91.79,123.96 89.04,126.71 89.04,131.09 v1(88.92,131.21)
  IN2 w1.016: 29.43,96.65 28.54,96.65 27.52,97.66 27.52,113.6 24.48,116.65 15.78,116.65 14.98,115.85 13.91,115.85 12.79,116.97 12.79,118.17
  IN3 w0.508: 46.26,103 46.26,104.71 45.05,105.92 45.05,115.38 v1(43.74,116.69) ; v1(111.08,139.71) 110.84,139.71 110.44,140.1 110.44,144.1 109.29,145.26 94.43,145.26 91.66,142.49 91.66,140.41 90.71,139.46 90.71,133 v1(88.92,131.21)
  BOTTOM w0.203: PU502.2 111.48,140.03 111.15,139.71 v1(111.08,139.71)
  BOTTOM w0.508: RE60.1 227.63,156.4 227.27,156.76 v1(221.52,156.76) ; PC503.1 82.9,134.89 83.79,134 85.06,134 86.16,132.89 86.16,131.65 86.63,131.18 88.88,131.18 v1(88.92,131.21)
  vias: v1(12.45,119.12) v1(13.08,119.12) v1(18.25,25.66) v1(18.84,25.66) v1(30.39,96.54) v1(30.98,96.54) v1(32.66,11.88) v1(33.24,11.88) v1(37.61,11.57) v1(38.19,11.57) v1(42.13,31.19) v1(42.13,30.6) v1(42.71,31.19) v1(42.71,30.6) v1(45.9,102.12) v1(102.18,32.97) v1(102.18,32.38) v1(102.18,31.8) v1(102.76,32.97) v1(102.76,32.38) v1(102.76,31.8) v1(103.34,32.97) v1(103.34,32.38) v1(103.34,31.8) v1(220.18,119.86) v1(220.18,119.28) v1(220.18,118.69) v1(220.18,118.11) v1(220.18,117.52) v1(223.84,59.48) v1(223.84,58.9) v1(223.84,58.32) v1(223.84,57.73) v1(223.84,57.15) v1(223.84,56.56) v1(223.84,55.98) v1(223.84,55.39)
+5VS_CRT: length 11.1
  TOP w0.102: v1(11.36,115.47) v4(11.36,116.28)
  TOP w0.33: U2.5 12.74,111.36 12.35,111.76 C9.2 ; v1(14,107.55) U1.5
  TOP w0.508: C9.2 v1(11.71,112.32)
  IN2 w0.508: v1(18.82,113.47) 16.54,113.47 14.25,111.19 14.13,111.19
  BOTTOM w0.508: R28.1 R27.1 18.56,113.74 v1(18.82,113.47)
  vias: v1(10.77,115.47)
+5VS_ODD: length 2.7
  TOP w0.102: v4(227.61,110.59) 227.61,112.49 JODD.9
+5VS_TOUCH: length 14
  TOP w0.102: 23.71,96.07 23.71,94.94 v2(23.26,94.49)
  TOP w0.508: v1(15.14,96.71) 15.66,97.23 RX24.1
  IN2 w0.508: v1(26.19,96.52) 24.6,96.52 24.22,96.9 15.33,96.9 v1(15.14,96.71)
+AVCC33: length 8
  TOP w0.203: v1(200.12,171.02) 200.15,170.98 UX4.5
  BOTTOM w0.102: v2(196.4,166.94) 196.65,167.19 LX8.1
  BOTTOM w0.508: v1(200.12,171.02) 200,170.9 CX31.1 CX33.1 199.04,169.67 198.35,168.98 CX35.1 197.49,168.39 LX8.1
+AVDD: length 7.6
  TOP w0.102: v1(167.09,115.41) 167.69,115.41 v2(167.81,115.52)
  TOP w0.508: LV12.1 163.15,112.64 CV77.1 164.11,113.22 164.95,114.06 CV76.1 CV75.1 166.35,114.06 166.73,114.44 166.73,115.08 167.06,115.41 v1(167.09,115.41)
  BOTTOM w0.203: UV1.AD34 167.58,115.89 v1(167.09,115.41)
+DVCC33: length 11.5
  TOP w0.102: v4(208.36,162.58) 208.05,162.89 LX7.1
  TOP w0.203: UX4.18 204.12,166.5 204.11,166.49 204.11,166.18 203.8,165.87 ; UX4.22 205.72,166.81 206.15,166.38 206.15,165.87
  TOP w0.254: 194.97,166.19 194.98,166.19 RP57.7 ; 194.97,166.19 194.97,167.33 195.32,167.68 v1(196.69,167.68) ; 194.97,166.19 194.97,165.94 195.22,165.69 RP57.8
  TOP w0.508: 198.97,174.89 199.29,174.89 v1(199.8,174.38)
  vias: v1(204.69,165.3) v1(207.04,163.59)
+V18R: length 5.9
  TOP w0.102: v2(176.18,39.67) 176.47,39.67 176.67,39.88 178.1,39.88 178.97,39 CE16.1
  TOP w0.203: CE16.1 179.41,38.91 UE1.124
+VCC_3IN1: length 24.4
  TOP w0.254: UR1.5 177.82,20.61 v1(178.21,20.22)
  TOP w0.762: CR8.1 188.76,29.16 v1(188.32,28.71) 187.29,28.71 v4(186.59,29.41) 182.85,29.41 182.81,29.37 182.71,29.37 182.26,28.92 CR7.1 182.27,28.57 v1(182.27,27.84)
  BOTTOM w0.508: v1(182.27,27.84) 182.36,27.92 JREAD.11 ; JREAD.4 189.2,29.16 188.75,28.71 v1(188.32,28.71)
  BOTTOM w0.762: v1(178.21,20.22) 178.64,20.65 180.24,20.65 181.58,21.98 181.58,22.68 182.36,23.46 182.36,27.76 v1(182.27,27.84)
+VCC_PWR_SRC: length 30.1
  TOP w0.508: 116.93,143.24 116.32,143.24 114.09,145.48 104.87,145.48 102.58,143.19 100.03,143.19 v2(97.77,145.45) 93.72,145.45 v1(91.66,143.39)
  BOTTOM w0.508: v1(91.66,143.39) PR508.1
  vias: v1(116.74,142.44) v1(117.38,142.44)
+VCCHDA: length 15.4
  TOP w0.508: RC129.2 RC128.2 RC127.2 122.29,98.63 122.01,98.91 v2(122.01,102.82) 121.16,103.67 121.16,109.2 v1(121.44,109.48) 121.63,109.67 C77.1
  BOTTOM w0.254: UC1.AH14 122.04,110.09 v1(121.44,109.48)
+VCCIO_OUT: length 4.2
  TOP w0.102: v4(89.75,130.15) 89.82,130.21 v1(89.82,130.76)
  BOTTOM w0.508: R245.2 92.55,130.76 v1(89.82,130.76)
+VCCIO_OUT_R: length 6.4
  BOTTOM w0.089: v2(94.37,129.93) R245.1
  BOTTOM w0.254: UC1.A59 94.38,126.01 93.36,127.03 93.36,128.15 92.75,128.77 92.75,129.56 R245.1
+VCCIOA_OUT: length 31.4
  TOP w0.254: RC71.1 117.75,124.86 v4(118.19,125.3)
  TOP w0.508: RC71.1 117.75,123.91 118.05,123.61 118.05,123.6 118.36,123.29 v1(118.67,123.29)
  IN1 w0.508: v1(122.75,129.84) 123.42,129.17 125.25,129.17 125.87,128.55 128.86,128.55 129.31,128.09 131.55,128.09 132.87,129.41 v1(135.87,129.41)
  IN2 w0.508: v1(122.75,129.84) 122.42,130.17 117.72,130.17 117.19,129.64 117.19,127.48 117.63,127.04 117.63,124.28 118.62,123.29 v1(118.67,123.29)
  BOTTOM w0.254: UC1.E20 118.76,123.29 v1(118.67,123.29)
  BOTTOM w0.508: RC78.1 135.66,129.21 v1(135.87,129.41)
+VCCRTCEXT: length 2.8
  TOP w0.254: C52.1 125.01,111.62 v2(125.62,111.62) 126.15,111.62 126.58,111.19 v1(126.58,111.14)
  BOTTOM w0.254: UC1.AE7 126.58,111.36 v1(126.58,111.14)
+VDD1DI: length 8
  TOP w0.102: v2(161.51,115.32) 161.68,115.14 LV13.1
  TOP w0.508: LV13.1 163.08,115.64 CV80.1 164.62,115.64 164.82,115.84 CV78.1 CV79.1 166.32,116.02 167.39,116.02 167.57,116.2 v1(168.2,116.2)
  BOTTOM w0.254: UV1.AC33 168.2,116.63 v1(168.2,116.2)
+VDD_MEM15_REFDA: length 24.7
  IN3 w0.508: 173.32,126.43 171.24,126.43 169.96,127.71 167.26,127.71 164.99,129.98 164.46,129.98 163.92,130.52 163.92,130.93 162.4,132.46 162.4,133.36 v1(160.87,134.88)
  BOTTOM w0.254: UV1.L18 180.46,126.72 v1(180.92,127.18)
  BOTTOM w0.508: CV220.1 RV146.1 RV139.2 160.74,130.63 159.91,131.46 v2(159.91,132.67) 159.91,134.17 160.63,134.88 v1(160.87,134.88)
+VDD_MEM15_REFDB: length 4.9
  BOTTOM w0.102: RV148.1 197.09,102.37 v2(197.64,101.82)
  BOTTOM w0.381: UV1.Y12 185.46,119.85 v1(185.08,120.23)
  BOTTOM w0.508: CV223.1 v1(195.43,103.27) ; CV223.1 RV148.1 ; CV223.1 196.2,102.46 RV141.2
+VDD_MEM15_REFSA: length 27.8
  TOP w0.102: v2(162.46,135.09) 162.92,134.63 v1(163.03,134.63)
  IN3 w0.508: v1(179.67,127.26) 179.11,127.26 178.65,126.79 176.53,126.79 176.31,126.57 175.61,126.57 175.01,127.16 171.71,127.16 168.57,130.31 166.46,130.31 165.32,131.45 164.3,131.45 163.03,132.72 v1(163.03,134.63)
  BOTTOM w0.254: v1(179.67,127.26) 179.46,127.05 UV1.L20
  BOTTOM w0.508: v1(163.03,134.63) 163.03,134.64 162.74,134.93 161.82,134.93 161.11,134.21 CV221.1 RV147.1 RV140.2
+VDD_MEM15_REFSB: length 25.4
  TOP w0.102: v1(194.63,104.57) v2(193.92,104.57)
  IN3 w0.508: v1(194.63,104.57) 194.63,106.26 191.52,109.37 191.52,111.68 189.87,113.33 189.37,113.33 189.32,113.39 188.75,113.39 188.71,113.42 188.08,113.42 187.48,114.03 187.48,115.33 187.05,115.76 186.45,115.76 186.08,116.12 186.08,118.11 v1(185.01,119.19)
  BOTTOM w0.381: UV1.AA12 185.46,118.73 v1(185.01,119.19)
  BOTTOM w0.508: RV142.2 RV149.1 CV224.1 195.75,105.95 194.63,104.84 v1(194.63,104.57)
+VDDC_CT: length 30.1
  TOP w0.508: CV174.1 CV173.1 173.99,114.78 174.27,114.49 174.27,113.47 v1(173.99,113.2)
  IN3 w0.508: v1(173.99,113.2) 173.89,113.2 173.3,112.6 173.3,111.31 174.3,110.31 174.3,107.45 174.91,106.84 175.05,106.84 176.48,105.4 176.48,102.19 175.96,101.67 175.96,98.34 v1(176,98.3)
  BOTTOM w0.254: v1(173.99,113.2) 174.46,113.67 UV1.AG26 UV1.AF26 UV1.AF27
  BOTTOM w0.279: v1(173.99,113.2) 173.5,113.69 UV1.AG27
  BOTTOM w0.508: v1(176,98.3) 175.57,98.3 174,96.73 CV171.1 CV172.1 CV170.1 LV19.2
+VDDCI: length 18.9
  BOTTOM w0.305: UV1.M16 182.46,125.58 v1(182.88,125.16) ; UV1.Y13 UV1.AA13 184.34,118.57 184.34,117.81 UV1.AB13 184.54,117.69 v1(185.06,117.17) ; UV1.N20 179.42,124.69 v1(178.91,125.19) ; UV1.R16 182.46,123.75 v1(182.9,124.19) 183.4,124.69 UV1.N15 UV1.N13 UV1.R12 185.47,123.69 v1(185.98,124.21) ; v1(183.83,117.18) 183.46,116.81 UV1.AC15 UV1.AD16 ; UV1.AC12 185.46,116.68 v1(185.01,116.23) 184.47,115.69 UV1.AD13 ; UV1.M23 176.46,125.61 v1(176.88,125.19) 177.38,124.69 UV1.N22 ; v1(183.92,122.21) 183.46,122.67 UV1.T15 ; v1(181.96,125.12) 181.53,124.69 UV1.N17 UV1.M18 ; UV1.V15 183.38,120.69 v1(182.85,120.16)
  BOTTOM w0.381: UV1.N13 UV1.M15
  vias: v1(182.97,115.19) v1(184.88,123.21) v3(193.89,182.45) v3(193.89,181.81) v3(193.89,181.18) v3(193.89,180.54) v3(193.89,179.91) v3(193.89,179.27) v3(194.53,182.45) v3(194.53,181.81) v3(194.53,181.18) v3(194.53,180.54) v3(194.53,179.91) v3(194.53,179.27) v4(181.5,109.43)
+VDDCIP: length 14.9
  BOTTOM w0.254: PR1208.1 180.81,188.22 181.2,188.61 187.13,188.61 v2(187.26,188.48) 191.8,188.48 192.24,188.03 192.24,185.56 192.05,185.37
+VDDR4: length 18.6
  TOP w0.102: v1(184.81,98.72) 184.81,99.38 v2(184.86,99.43)
  IN1 w0.508: v1(185,114.18) 184.14,113.31 184.14,112.04 183.86,111.76 183.86,106.75 184.3,106.3 184.3,104.78 v1(183.54,104.02)
  IN3 w0.508: v1(184.81,98.72) 184.11,99.42 184.11,103.44 v1(183.54,104.02)
  BOTTOM w0.508: v1(184.81,98.72) 185.02,98.92 LV20.2
  vias: v1(184.94,115.19) v1(186.02,114.18)
GND: length 3425
  TOP w0.203: v1(203.26,166.52) 203.32,166.58 UX4.16 ; v1(184.16,50.1) 183.99,50.28 UE1.94 ; v1(30.95,19.5) 30.8,19.65 UA1.4 ; v1(71.23,43.52) 71.43,43.31 UG1.13 ; UE1.24 192.39,36.77 v1(192.14,37.02) ; v1(195.98,38.17) 196.05,38.11 UE1.35 ; UX4.6 202.26,170.58 v1(202.85,171.17) ; v1(180.24,43.61) 180.24,43.61 180.55,43.31 UE1.113 ; U2304.11 v1(141.95,24.9) ; UG1.4 v1(71.83,39.67) ; v1(187.06,37.09) 187.06,36.95 187.19,36.82 UE1.11 ; UG1.7 73.03,40.1 73.33,39.8 v1(73.45,39.8)
  TOP w0.254: v1(208.36,132.68) 207.96,133.08 UV7.J10 ; v1(177.61,104.98) 177.12,105.47 RP47.4 ; v1(169.11,146.05) 168.71,145.65 UV5.J10 ; RP45.6 73.42,112.4 v1(73.17,112.15) 73.42,111.9 RP45.7 ; UV3.J10 189.2,145.62 188.83,145.98 v1(188.82,145.98) ; v1(208.17,113.09) 208.17,113.08 207.8,112.71 UV9.J10
  TOP w0.305: UV3.R3 v1(184.79,150.78) UV3.R4 v1(183.99,149.98) UV3.T5 ; UV3.N12 v1(186.39,144.38) ; UV5.P10 164.68,145.65 v1(165.08,146.05) ; v1(192.01,150.77) 192.4,151.16 UV3.E3 ; v1(211.16,134.74) 211.23,134.81 211.85,134.81 UV7.L5 ; UV9.F10 207.75,110.31 v1(207.36,109.92) ; v1(215.62,107.82) 215.53,107.91 UV9.C1 ; UV7.T5 v1(211.56,139.11) ; v1(211.4,106.71) 211.77,107.08 UV9.B5 ; UV5.A14 175.09,141.89 v1(175.11,141.87) ; v1(212.18,115.5) 211.84,115.16 211.82,115.16 UV9.M5 ; UV3.R14 184.4,141.81 v1(184.39,141.81) ; UV9.N14 v1(203.97,115.91) ; UV5.C4 v1(173.88,150.85) ; UV9.D10 207.77,108.71 v1(208.17,109.11) ; v1(171.92,153.49) 171.92,152.88 UV5.E1 ; v1(186.4,150) 186.74,149.65 186.74,149.64 UV3.M5 ; UV3.F10 191.6,145.56 v1(191.98,145.17) ; v1(215.73,136.31) 215.73,136.31 UV7.N1 ; UV9.G5 211.69,111.11 v1(211.31,110.74) 211.74,110.31 UV9.F5 ; v1(189.59,152.38) 189.99,151.98 UV3.H2 ; v1(188.4,141.8) 188.4,141.8 UV3.K14 188.35,142.43 188.35,143.14 UV3.K13 ; UV5.B10 174.28,145.65 v1(173.88,146.05) ; v1(162.53,141.93) 162.28,142.17 UV5.U14 ; UV7.E3 213.54,129.91 v1(213.15,130.29) ; UV7.U14 204.25,139.51 v1(204.25,139.53) ; v1(173.49,141.82) UV5.C14 UV5.C13 ; v1(213.16,127.91) 212.76,128.31 UV7.C4 ; UV7.H14 204.69,132.24 v1(204.13,132.24) ; UV3.R12 184.39,143.98 v1(183.99,144.38) ; UV9.E3 213.35,109.51 v1(212.96,109.9) ; v1(169.56,141.82) 169.56,142.38 UV5.H14 ; v1(195.23,143.58) 195.23,143.62 195.6,143.99 UV3.A12 ; UV9.N1 v1(215.54,115.91) ; UV5.G5 170.29,149.56 v1(170.66,149.19) 171.09,149.62 UV5.F5 ; UV9.M10 v1(207.37,115.51) ; UV9.R1 v1(215.54,117.51) ; UV9.E14 v1(203.94,109.51) ; UV5.R12 v1(163.48,144.45) ; v1(208.36,129.51) 207.96,129.11 UV7.D10 ; UV3.N14 v1(186,141.78) ; v1(68.95,111.34) 69.12,111.34 69.35,111.11 JTP.4 ; v1(211.59,127.1) 211.96,127.48 UV7.B5 ; v1(193.59,151.58) 193.99,151.18 UV3.C3 v1(194.39,151.58) ; UV9.U3 213.37,119.11 v1(213.37,119.63) ; UV3.U1 182.73,152.85 v1(182.27,152.85) ; UV7.A3 213.56,126.71 v1(213.16,126.31) ; v1(190.39,152.38) 190,152.78 UV3.H1 ; UV5.N14 v1(165.48,141.85) ; UV9.C13 UV9.C14 v1(203.94,107.91) ; UV3.C12 194,143.99 v1(194.39,144.38) ; UV3.R1 184.4,153.36 v1(184.39,153.36) ; UV3.L5 187.58,149.58 187.1,149.11 v1(187.04,149.11) ; UV7.C1 215.72,128.31 v1(215.81,128.21) ; UV5.H13 169.49,143.24 v1(169.89,142.84) ; v1(204.18,126.68) 204.21,126.71 UV7.A14 ; UV9.A1 214.97,105.88 214.88,105.78 v1(214.88,105.79) ; v1(208.17,107.51) 207.77,107.11 UV9.B10 ; UV5.R14 v1(163.88,141.87) ; UV3.C1 194.09,152.87 v1(194.09,153.3) ; UV7.E12 206.36,129.93 v1(206.74,130.3) ; UV9.A14 204.02,106.31 v1(203.99,106.28) ; UV5.H2 169.48,152.05 v1(169.08,152.45) ; v1(195.2,149.21) 194.83,149.58 UV3.B5 ; UV9.T5 v1(211.37,118.71) ; v1(194.39,150.78) 194,150.39 UV3.C4 ; v1(175.48,150.85) 175.09,151.25 UV5.A3 ; UV7.P10 v1(208.36,136.71) ; UV5.F10 171.09,145.63 v1(171.47,145.24) ; v1(188.79,153.18) UV3.K1 188.4,152.78 v1(188.79,152.38) UV3.K2 188.4,151.98 v1(188.79,151.58) ; UV3.D10 193.19,145.58 v1(192.79,145.98) ; v1(213.77,113.11) 214.17,113.51 UV9.K2 v1(214.57,113.11) 214.97,113.51 UV9.K1 v1(215.37,113.11) ; UV9.C11 v1(207.37,107.51) ; UV3.T10 v1(184,145.98) ; UV9.T10 v1(208.17,117.91) ; UV3.G10 v1(191.19,145.98) ; v1(166.23,149.12) 166.23,149.6 UV5.M5 ; v1(215.61,109.48) 215,109.48 UV9.E1 ; UV9.K13 205.33,113.55 204.61,113.55 UV9.K14 203.99,113.51 v1(203.99,113.51) ; v1(195.66,141.87) 195.66,141.88 195.6,141.95 UV3.A14 ; UV7.U12 206.36,139.51 v1(206.76,139.11) ; v1(214.57,112.31) 214.17,111.91 UV9.H2 ; UV7.R4 v1(212.36,138.31) ; UV5.R3 163.88,151.25 v1(164.28,150.85) ; UV7.K2 v1(214.76,133.51) 215.16,133.91 UV7.K1 v1(215.56,133.51) ; v1(208.36,134.35) 208,134.71 UV7.L10 207.96,134.71 208.36,135.11 UV7.M10 v1(207.56,135.91) ; v1(215.23,140.03) 215.23,139.58 UV7.U1 ; UV5.G10 v1(170.68,146.05) ; UV3.U14 v1(182.79,141.87) ; UV3.F5 191.6,149.55 v1(191.17,149.13) 190.8,149.5 UV3.G5 ; UV5.U1 162.18,152.74 v1(161.73,152.74) ; v1(173.58,153.5) 173.49,153.41 UV5.C1 ; UV9.G10 v1(208.17,110.71) ; v1(167.89,141.86) 167.89,141.87 UV5.K14 167.84,142.49 167.84,143.2 UV5.K13 ; UV5.B5 174.32,149.65 v1(174.69,149.28) ; v1(206.76,138.31) 206.36,137.91 UV7.R12 ; UV3.N1 186,153.36 v1(185.99,153.36) ; UV7.E14 v1(204.13,129.91) ; UV5.L5 166.98,149.54 166.98,148.92 v1(167.05,148.84) ; v1(208.36,127.91) 207.96,127.51 UV7.B10 ; UV3.B10 194.79,145.58 v1(194.39,145.98) ; UV7.R11 207.16,137.91 v1(207.56,138.31) ; UV3.A3 195.6,151.18 v1(196,150.78) ; v1(168.28,153.25) UV5.K1 167.89,152.85 v1(168.28,152.45) UV5.K2 ; v1(214.76,131.91) 215.16,132.31 UV7.H1 ; v1(213.33,140.03) 213.56,139.79 UV7.U3 ; UV7.C11 207.16,128.31 v1(207.56,127.91) ; UV7.H13 205.55,132.31 v1(205.15,131.91) ; v1(212.97,105.91) 213.37,106.31 UV9.A3 ; v1(174.72,143.65) 175.09,144.02 UV5.A12 ; UV7.G10 v1(208.36,131.11) ; UV3.U3 v1(182.27,151.18) ; v1(172.28,146.05) 172.68,145.65 UV5.D10 ; v1(204.19,137.91) 204.19,137.91 UV7.R14 ; UV9.H13 205.37,111.89 v1(204.96,111.48) 204.57,111.87 UV9.H14 ; v1(212.97,115.51) 213.37,115.91 UV9.N3 ; UV7.E1 215.19,129.87 v1(215.81,129.87) ; UV9.L5 211.77,114.33 v1(212.12,114.68) ; UV5.E3 171.89,151.22 v1(171.5,150.84) ; UV3.L10 187.2,145.98 v1(187.16,145.98) ; UV7.R1 215.73,137.91 v1(215.73,137.91) ; UV3.P10 v1(185.6,145.98) ; UV9.R14 v1(203.99,117.51) ; UV5.N1 v1(165.48,153.42) ; UV9.E12 206.17,109.53 v1(206.55,109.91) ; v1(213.77,108.31) 213.37,107.91 UV9.C3 v1(213.77,107.51) ; v1(192,144.36) 192.37,143.98 UV3.E12 ; UV3.R11 184.39,144.78 v1(183.99,145.18) ; UV5.N3 165.48,151.25 v1(165.88,150.85) ; v1(215.04,119.63) 215.04,119.18 UV9.U1 ; UV9.R4 v1(212.17,117.91) ; UV5.C12 v1(173.88,144.45) ; UV3.M10 v1(186.39,145.18) ; UV5.T5 v1(162.68,149.25) ; UV9.U14 v1(204.05,119.11) ; UV7.F10 207.94,130.71 v1(207.55,130.32) ; UV7.K13 205.52,133.95 204.8,133.95 UV7.K14 204.18,133.91 v1(204.18,133.9) ; UV7.N3 v1(213.16,135.91) ; v1(206.57,117.91) 206.17,117.51 UV9.R12 ; v1(196.12,152.69) 196.12,152.69 196.03,152.78 UV3.A1 ; v1(173.08,151.65) 173.48,151.25 UV5.C3 v1(173.88,151.65) ; UV9.N12 v1(206.57,115.51) ; UV7.N12 v1(206.76,135.91) ; v1(194.39,145.18) 194,144.79 UV3.C11 ; UV7.H2 214.36,132.31 v1(214.76,132.71) ; UV5.R4 v1(163.48,150.05) ; UV7.A12 206.33,126.71 v1(205.96,127.07) ; UV5.N12 v1(165.88,144.45) ; UV3.E1 192.43,152.82 v1(192.43,153.43) ; UV5.T10 163.09,145.65 v1(163.48,146.05) ; UV9.U12 v1(206.57,118.71) ; UV9.R11 206.97,117.51 v1(207.37,117.91) ; v1(211.43,135.56) 211.91,135.56 UV7.M5 ; UV9.C12 v1(206.57,107.51) ; v1(175.6,152.76) 175.61,152.76 175.52,152.85 UV5.A1 ; v1(165.88,145.25) UV5.M10 166.68,146.05 167.08,145.65 UV5.L10 167.09,145.69 v1(167.45,146.05) ; v1(204.13,128.31) UV7.C14 UV7.C13 ; UV3.H14 190.03,142.38 v1(190.42,142.77) 190.01,143.18 UV3.H13 ; UV3.N3 v1(186.39,150.78) ; UV9.C4 v1(212.97,107.51) ; UV5.U12 v1(162.68,144.45) ; UV7.C12 206.36,128.31 v1(206.76,127.91) ; UV5.E14 v1(171.89,141.82) ; v1(213.96,127.91) UV7.C3 213.56,128.31 v1(213.96,128.71) ; UV5.H1 169.49,152.85 v1(169.88,152.45) ; UV7.G5 211.88,131.51 v1(211.5,131.13) 211.93,130.71 UV7.F5 ; UV9.P10 v1(208.17,116.31) ; UV3.E14 v1(192.4,141.76) ; v1(171.49,144.42) 171.86,144.05 171.88,144.05 UV5.E12 ; v1(214.57,111.51) 214.97,111.91 UV9.H1 ; UV5.C11 v1(173.88,145.25) ; v1(208.17,114.75) 208.17,114.71 UV9.L10 ; UV5.R11 v1(163.48,145.25) ; UV9.A12 v1(206.57,105.91) ; v1(215.07,126.19) 215.07,126.18 215.16,126.27 UV7.A1 ; UV5.R1 v1(163.88,153.42) ; UV7.N14 v1(204.16,136.31) ; v1(194,141.76) UV3.C14 UV3.C13 ; UV5.U3 v1(161.76,151.25) ; v1(183.19,144.38) 182.8,143.98 UV3.U12 ; UV7.R3 v1(213.16,138.31) ; UV9.R3 v1(212.97,117.91) ; UV7.T10 v1(208.36,138.31)
  TOP w0.33: U1.3 14.8,108.85 v1(14.53,108.58) ; v1(14.76,112.66) U2.3
  TOP w0.381: UD1.3 49.37,16.09 49.27,15.99 v1(49.27,14.69) ; PQ2.1 128.22,168.81 128.03,168.99 v1(128.03,169.29) ; UE2.3 179.43,51.83 v1(179.61,51.66) ; PQ2.4 131.17,167.51 131.35,167.33 v1(131.35,166.95) ; CV211.2 182.56,126.84 182.02,126.3 182.02,126.2 v1(181.96,126.13) ; UI5.1 205.87,42.7 205.2,43.38 v1(205.2,44.03) ; PQ1.1 128.22,172.44 128.32,172.34 PC5.2 ; UI4.1 20.34,30.44 v1(20.48,30.3) ; PQ3.4 131.3,162.3 131.8,161.8 PR32.2 ; U2303.3 44.77,66.61 v1(44.22,67.16) ; UI2.1 29.26,52.06 29.43,51.89 29.43,51.67 29.2,51.45 v1(28.95,51.45)
  TOP w0.406: UC3.3 146.95,106.46 v1(147.32,106.82) ; PD101.1 v1(123.38,13.98)
  TOP w0.457: v1(172.04,43.93) 171.64,44.32 DE1.1 ; PC856.2 180.2,122.8 v1(179.96,123.04)
  TOP w0.508: v1(106.43,124.08) 106.14,124.37 PC904.2 ; RC99.2 133.58,116.8 v1(133.53,116.75) ; v1(170.02,164.28) PR712.2 ; CE1.2 200.37,36.9 v1(201.07,37.6) ; PC873.2 172.18,118.81 PC872.2 172.68,117.94 v1(172.94,118.2) ; v1(225.26,176.54) 224.69,177.11 CX5.2 ; RV9.2 206.4,143.77 v1(205.96,144.22) 205.52,143.77 CV25.2 ; C11.2 v1(9.48,114.25) ; PC903.2 103.63,124.37 v1(103.92,124.08) ; v1(173.96,119.32) 173.58,118.93 PC871.2 ; CC15.2 61.11,94.56 v1(61.56,95.01) ; v1(204.78,164.22) 205.58,164.22 205.64,164.28 205.65,164.28 CX41.2 ; CV149.2 171.21,126.62 CV151.2 169.82,126.06 v1(169.75,125.99) ; RX5.1 198.68,166.75 CX32.2 198.68,167.93 198.73,167.98 v1(198.73,168.25) ; CV187.2 177.3,111.91 v1(177.3,111.32) ; CC34.2 134.36,112.37 v1(134,112.01) ; v1(177.96,123.19) 177.84,123.19 PC865.2 ; PC844.2 PC854.2 175.37,117.63 v1(174.91,118.08) ; R2351.1 45.04,63.82 45.56,64.34 45.56,64.7 v1(45.7,64.84) ; v1(183.99,33.06) 183.99,33.03 184.09,32.93 CE27.2 CE6.1 ; v1(158.46,153.68) 158.13,153.35 CV387.2 RV34.2 ; v1(165.26,127.77) 165.34,127.86 CV97.2 ; C83.2 120.1,118.56 v1(120.23,118.56) ; CG10.2 v1(70.23,37.39) ; CV205.2 184.41,120.65 CV203.2 184.42,120.72 CV208.2 184.42,121.73 184.89,122.2 v1(185.01,122.2) ; SW1.6 200.23,31.81 v1(200.24,31.82) ; PC13.1 131.22,180.79 v1(131.6,181.18) 131.09,181.68 PR26.1 ; CI13.2 24.9,65.19 v1(25.98,66.27) ; RV64.1 178.32,105.69 v1(177.61,104.98) ; RE2.1 128.22,94.8 128.53,95.11 128.54,95.11 128.74,95.32 128.74,95.32 v1(128.81,95.39) 129,95.58 CC3.1 ; v1(173.66,108.33) 173.69,108.36 CV109.2 ; v1(204.5,146.45) CV198.2 203.79,146.47 CV197.2 ; CC33.2 151.45,107.03 151.01,106.59 v1(150.84,106.59) ; CA25.1 20.92,18.82 v1(20.92,18.36) ; v3(125.72,11.39) 125.82,11.5 PR105.2 ; v1(171.07,46.07) CE35.2 ; PC860.2 182.35,120.74 v1(182.89,121.27) ; CV156.2 186.53,116.79 v1(186.98,116.34) 186.54,115.9 CV194.2 ; v1(196.47,170.44) 196.47,170.86 RX25.2 ; v1(176.95,123.03) 177.27,122.71 PC864.2 ; PC843.2 180.45,117.52 v1(180.01,117.08) ; v1(108.94,124.08) 108.64,124.37 PC905.2 ; RV162.1 199.8,127.39 199.44,127.75 v1(199.44,128.94) ; v1(220.76,92.28) 220.63,92.28 220.45,92.45 PC603.2 PR604.2 ; PC847.2 180.51,115.73 v1(179.95,115.17) ; v1(163.03,102.82) 162.91,102.94 CV110.2 ; v1(175.62,43.72) 174.96,44.39 CE30.2 ; v1(66.9,64.66) 67.61,63.95 CD16.2 68.98,63.95 CD5.2 ; CX47.2 198.4,161.78 v1(197.88,162.3) ; CA56.2 32.73,14.5 CA55.2 33.37,13.98 33.81,13.54 v1(33.81,12.35) ; v1(127.22,123.39) 126.91,123.7 RC87.1 ; CV399.2 RV184.2 167.87,138.17 v1(167.48,138.57) ; v1(151.29,122.18) 151.24,122.13 Q2308.3 ; CR9.2 179.52,27.98 v1(178.9,27.98) ; v1(11.08,111.92) 11.08,111.28 DE5.1 ; v1(173,123.07) 173.29,123.36 CV147.2 CV148.2 ; v1(126.8,171.9) 126.9,172.01 PC5.2 ; v1(95.45,119.43) 96.76,119.43 PC908.2 ; v1(177.96,116.32) 177.82,116.17 PC852.2 ; SW1.5 v1(198.97,27.44) ; CX48.2 198.81,165.03 198.16,165.03 v1(197.82,164.69) ; C48.2 26.41,102.36 v1(25.75,102.36) ; C71.2 121.7,117.38 v1(122.3,116.77) ; PC711.1 PR711.1 v1(172.94,167.21) ; v1(222.95,160.67) JKB.32 ; CV131.2 155.72,111.7 CV126.2 CV127.2 ; v1(218.81,64.08) CS6.2 CS5.2 ; CC4.1 134.03,95.51 v1(134.57,94.98) ; CV173.2 CV174.2 172.68,113.86 171.91,113.08 RV204.2 171.91,112.25 v1(171.33,111.67) ; v1(210.09,175.84) 210.09,176.29 210.4,176.6 211.19,176.6 RX20.2 ; v1(82.01,64.65) 82.58,64.08 CD22.2 CD21.2 ; CV329.2 RV238.2 168.41,98.99 v1(168.94,99.51) ; CE12.2 188.32,32.69 CE28.2 v1(189.06,32.7) ; v1(23.27,28.97) RA31.2 ; CV199.2 v1(204.45,145.44) ; CV335.2 RV201.2 154.5,109.27 v1(154.36,109.13) ; CI6.2 v1(32,51.48) ; v1(210.6,40.9) 210.6,40.27 210.05,39.72 CI31.2 ; C2309.2 95.72,24.71 v1(95.41,24.39) ; v1(210.47,43.83) 210.47,43.63 210.07,43.24 CI32.2 CI25.2 ; CI15.2 v1(21.43,66.34) ; v1(13.81,103.38) C25.2 C23.2 ; v1(25.24,110.93) 24.92,110.62 C27.2 ; v1(184.21,59.32) 183.94,59.05 Q2307.3 ; C2311.2 C2313.2 141.89,23.19 v1(141.95,23.12) ; CM40.2 95.23,146.49 v1(94.83,146.89) ; v1(76.1,64.91) 75.72,64.53 CD12.2 76.28,63.4 CD9.2 ; JPWR.4 42.34,94.5 v1(42.09,94.24) ; v1(180.32,104.02) CV323.2 ; C66.2 C64.2 117.77,95.5 117.57,95.7 v1(117.57,96.49) ; v1(106.5,149.55) 105.69,148.75 CM47.2 ; v1(118.95,15.28) 119,15.22 PC100.2 ; CI7.2 CI26.2 v1(32.11,55.75) ; RE1.1 93.77,121.41 93.95,121.23 v1(93.95,121) ; v1(22.85,110.28) 22.89,110.23 C93.2 ; CV214.2 181.54,105.4 v1(181.68,105.26) 181.64,105.22 RV89.1 ; CD49.2 156.94,72.15 156.44,71.65 CD39.2 155.73,73.04 v1(156.05,73.35) ; v1(164.62,111.77) 164.99,111.77 RV207.2 ; CC7.1 114.45,135 114.45,135.01 114.45,135.34 v1(114.27,135.52) ; CE18.1 v1(177.97,44.84) ; C88.2 117.86,116.1 v1(118.22,116.1) ; v1(129.82,64.57) 129.32,64.07 CD34.2 ; v1(122.15,114.95) C82.2 C78.2 ; CV79.2 CV78.2 164.59,114.93 v1(164.54,114.87) 163.91,114.24 CV80.2 ; CV188.2 175.22,113.48 174.51,112.77 CV189.2 174.51,112.22 v1(174.84,111.89) ; CI16.2 v1(24.29,34.74) ; v1(137.44,164.73) 137.82,165.11 PC4.2 PC3.2 ; CG1.2 71.83,46.28 v1(72.04,46.48) ; JTP.7 74,108.62 v1(74.19,108.81) ; v1(98.52,124.08) 98.16,124.43 PC901.2 ; CD47.2 149.7,72.15 149.2,71.65 CD41.2 148.56,72.59 v1(149.44,73.48) ; CE20.2 195.75,31.71 v1(196.18,32.14) 195.93,32.4 RE18.2 ; UX1.2 216.63,168.67 216.93,168.97 v1(217.45,168.97) ; RL35.1 43.39,84.83 v1(43.59,85.04) ; v1(172.11,107.38) 172.81,106.68 CV108.2 ; v1(159.26,102.81) 159.61,103.16 CV121.2 CV122.2 158.15,103.51 CV120.2 ; v1(215.39,43.35) 215.09,43.05 JDB.10 ; v1(122.2,15.83) 122.69,15.83 122.79,15.73 122.8,15.73 123.03,15.5 PR114.2 ; CS7.2 v1(217.16,59.66) ; CA57.2 33.62,17.03 v1(33.62,17.98) CA58.2 ; v1(155.22,115.83) CV128.2 CV129.2 ; CE11.2 200.69,39.82 v1(201.27,39.24) ; v1(35.97,19.25) CA22.2 CA21.2 ; CX1.2 215.55,173.99 215.55,174.7 215.17,175.08 v1(214.91,175.08) 214.91,175.5 QX1.3 ; CV207.2 180.45,126.48 CV210.2 181.28,126.51 CV212.2 181.63,126.46 v1(181.96,126.13) ; SW1.1 v1(195.36,27.43) ; RV11.2 CV27.2 200.33,130.97 v1(199.92,130.56) ; v1(128.03,169.29) 128.57,169.82 PR29.2 128.77,170.2 PR2.2 ; v1(182.96,123.19) 183.41,123.19 183.97,123.75 CV204.2 183.54,124.46 CV209.2 ; v1(60.87,87.44) 61.37,87.95 CC31.2 ; PR108.2 PR107.1 v1(130.71,11.44) ; CV84.2 CV83.2 171.36,108.35 v1(171.29,108.27) ; CI24.2 v1(15.45,34.99) ; QD20.3 v1(69.65,15.89) ; C53.2 123.64,119.19 v1(123.45,119) ; CV324.2 177.77,126.29 v1(177.9,126.16) ; PC863.2 174.26,116.03 v1(173.95,116.34) ; CD52.2 CD53.2 161.19,64.27 v1(160.81,64.65) ; v1(122.77,72.88) 122.42,72.53 CD33.2 CD32.2 ; v1(111.44,124.08) 111.15,124.37 PC906.2 ; v1(193.59,32.08) 193.96,32.45 CE29.2 ; v1(134.45,117.7) 134.6,117.85 RC113.2 ; CR11.2 175.4,28.14 v1(175.92,28.14) ; CV322.2 183.41,116.48 182.96,116.92 v1(182.96,117.19) ; C51.2 149.97,105.97 v1(149.97,106.41) ; PC845.2 176.42,118.8 v1(175.96,119.26) ; CC14.2 60.23,97.74 v1(60.16,97.67) ; v1(13.81,106.38) C26.2 ; v1(28.1,11.25) 28.1,11.91 RA32.2 ; v1(162.51,106.64) 162.32,106.82 CV114.2 CV115.2 ; v1(79.59,65.16) 79.59,64.21 CD18.2 ; CD10.2 76.83,71.6 v1(78.01,72.78) ; CV390.2 RV33.2 v1(200.96,154.38) ; CE31.2 v1(197.55,32.89) ; v1(135.98,164.22) 136.44,164.68 PQ706.3 ; v1(35.7,22.81) RA19.2 ; v1(119.66,114.31) 119.8,114.45 C87.2 ; CD14.2 82.68,72.95 v1(82.39,73.24) ; JDB.9 213.9,56.66 v1(214.6,57.35) ; PC846.2 177.44,120.67 v1(177.96,121.19) ; CV35.2 RV20.2 214.96,99.18 v1(215.23,99.45) ; v1(139.3,181.44) 139.74,181.89 PD2.1 ; CG9.2 v1(67.1,41.09) ; CG11.2 70.53,47.38 v1(69.8,46.66) CG6.2 ; CD23.2 v1(48.43,66.67) ; PC859.2 180.37,120.74 v1(180.95,121.31) ; CD6.2 v1(65.43,62.48) ; v1(123.9,117.46) 123.86,117.41 C50.2 ; PQ4.3 v1(127.52,180.35) ; CA69.2 v1(32.15,27.38) ; v1(171.75,50.76) 171.86,50.76 172.44,50.18 CE32.2 ; C13.2 C12.2 14.24,114.95 13.81,115.38 v1(13.11,115.38) ; JTOUCH.7 25.58,98.84 v1(26,98.42) ; v1(211.67,50.7) 211.67,50.7 JDB.6 ; CV127.2 v1(156.68,110.94) ; CV127.2 CV130.2 ; v1(103.34,67.14) 102.82,67.14 102.44,67.52 RD7.1 RD6.1 ; v1(189.25,108.26) 189.22,108.28 CV154.2 ; v1(92.65,116.51) 92.63,116.49 RC132.2 ; v1(134.28,183.54) PR9.1 ; RM11.1 114.7,147.7 CM43.2 v1(114.08,149.49) ; C96.2 93.17,119.97 92.7,119.5 v1(92.65,119.5) ; v1(161.68,100.59) 161.4,100.31 CV124.2 CV125.2 159.25,99.83 CV123.2 ; PC907.2 113.66,124.37 v1(113.95,124.08) ; v1(13.03,108.25) C10.2 ; v1(181.96,117.05) 182.42,117.51 PC841.2 ; CV195.2 CV196.2 175.43,123.62 v1(175.97,123.08) ; v1(150.33,64.72) 150.33,64.4 150.65,64.08 CD43.2 150.16,63.46 CD36.2 ; YG1.2 66.44,39.53 66.79,39.18 v1(67.1,39.18) ; R2.2 90.95,134.94 v1(91.41,135.39) ; CG2.2 v1(71.15,37.37) ; PC910.2 96.87,116.41 95.99,115.53 v1(95.45,115.53) ; v3(132.01,22.01) 131.65,22.01 131.28,21.64 PC103.2 ; CC11.2 v1(150.41,102.75) 150.22,102.56 R159.2 ; DE4.1 13.02,106.65 v1(13.3,106.93) ; CR2.2 v1(179.06,15.81) ; v1(183.73,33.89) 183.61,33.77 CE33.2 ; v1(133.19,161.8) PR32.2 ; C60.2 130,124.03 C62.2 129.39,123.97 v1(129.3,123.89) ; v1(125.05,108.44) 124.65,108.84 C81.2 ; CR5.2 180.64,21.83 180.2,22.26 v1(180.2,22.69) CR10.2 ; v1(200.75,109.85) 200.31,110.3 RV169.1 ; v1(173.83,122.2) 173.9,122.13 PC855.2 ; v1(155.92,149.17) 156.11,149.17 157.64,147.65 RV186.2 158.13,147.33 158.33,147.13 158.33,146.19 158.66,145.86 CV400.2 ; CI30.2 209.52,40.52 v1(209.9,40.9) ; v1(213.33,175.14) 213.33,175.63 RX23.2 ; v1(190.85,91.96) 191.3,91.51 RV137.2 ; v1(221.45,134.27) JKB.31 ; v1(179.96,118.36) 180,118.4 PC851.2 ; RV206.1 176.25,125.54 v1(175.89,125.17) ; v1(163.73,109.82) 164.03,110.12 164.03,111.52 CV77.2 ; v1(181.96,124.25) 182.35,123.86 PC858.2 ; v1(182.66,54.68) 183.18,54.68 CE26.2 ; v1(44.22,72.84) 44.1,72.72 CD2.2 CD1.2 ; RV248.1 167.02,107.3 v1(166.52,106.8) ; CV349.2 RV194.2 187.1,138.12 v1(186.72,138.5) ; CV325.2 178.98,111.14 RV125.2 179.51,110.56 v1(179.67,110.72) ; v1(172.04,43.93) 172.13,43.84 CE34.2 ; v1(170.46,130.3) 169.62,129.47 CV143.2 CV150.2 ; v1(175.96,118.06) 175.84,118.06 175.37,118.54 PC866.2 ; CX34.2 203.99,163.97 v1(204.25,163.71) 203.72,163.19 CX40.2 ; PC850.2 178.21,118.55 v1(177.96,118.3) ; v1(118.22,112.85) 118.46,112.85 118.9,113.29 C69.2 ; CV222.2 v1(209.07,100.6) ; v1(169.06,116.23) 169.47,115.83 RV133.1 ; v1(92.62,127.65) C95.2 ; v1(174.17,17.55) 174.57,17.16 RR1.2 ; C73.2 v1(120.87,116.02) ; v1(89.83,19.82) 88.71,20.94 Q8.3 ; v1(196.37,55.34) 196.31,55.28 CE8.2 RE5.1 194.62,55.5 LE2.1 ; CC6.1 118.92,133.92 v1(117.97,132.97) ; v1(20.49,117.8) Q3.3 ; RC90.2 122.27,111.08 C77.2 121.63,111.25 v1(121.02,111.86) ; v1(101.41,124.08) 101.12,124.37 PC902.2 ; CG8.2 v1(67.17,39.82) ; v1(169.96,175.46) 170.4,175.01 PQ708.3 170.83,175.65 171.07,175.89 PR724.1 ; v1(177.26,26.44) 177.32,26.5 CR6.2 ; v1(20.86,109.03) 21.12,108.76 R25.2 ; CD3.2 51.27,64.21 v1(51.85,64.78) ; CX36.2 209.07,164.86 209.45,164.48 v1(209.45,164.09) ; v1(157.43,64.95) 157.89,64.49 CD50.2 157.33,63.4 CD38.2 ; CE19.2 v1(178.79,56.22) CE15.2 ; YG1.4 v1(62.58,41.13) ; C9.1 11.73,113.23 v1(11.08,112.58) ; RV145.1 206.66,99.2 207.1,98.75 v1(207.17,98.75) ; v1(17.24,98.49) 17.59,98.84 JTOUCH.8 ; v1(118.44,109.89) 118.44,110.36 119.08,111 C67.2 ; v1(122.05,112.61) 122,112.66 C76.2 ; CA32.2 v1(66.45,19.33) ; v1(171.32,130.29) 171.32,130.36 170.58,131.1 170.58,132.14 CV142.2 CV153.2 ; PC840.2 182.96,122.2 v1(182.96,122.19) ; v1(12.6,103) 12.06,102.46 DE3.1 ; v1(39.12,117.66) 39.12,116.61 39.48,116.25 R15.2 ; CL43.2 38.32,88.52 v1(38.76,88.96) ; v1(178.52,38.17) CE5.1 ; v1(180.96,119.19) 181.62,119.85 PC842.2 ; v1(153.62,64.67) 154.27,64.02 CD45.2 153.78,63.46 CD35.2 ; CA30.2 66.09,22.98 CA31.2 v1(67.2,22.63) ; v1(88.61,123.35) 88.69,123.43 88.69,124 RC163.2 ; C52.2 124.49,112.86 124.28,113.07 v1(123.78,113.07) 123.85,113.15 C68.2 ; v1(15.76,13.66) 16.44,14.34 DA12.1 ; CD64.2 44.9,61.12 v1(44.86,61.08) ; v1(94.77,24.42) 94.52,24.67 C2322.2 ; v1(179.96,124.28) 180.26,123.98 PC857.2 ; PC523.2 83.49,136.71 v1(83.93,137.15) ; v1(128.68,120.98) 128.74,121.04 C57.2 ; CR4.1 v1(171.59,22.17) ; v1(175.98,116.34) 176.04,116.28 PC861.2 176.19,115.55 CV190.2 ; v1(61.97,107.3) 62.24,107.3 62.59,106.95 JTP.8 ; v1(48.34,100.66) JPWR.5 ; v1(172.81,138.63) 172.37,138.19 RV25.1 ; R16.2 v1(89.36,19.19) ; v1(17.94,110.36) C20.2 ; CR1.2 v1(177.98,16.44) ; PC862.2 179.11,113.04 v1(178.96,113.19) ; PC1304.2 v1(196.23,64.22) 195.99,63.98 PR1301.2 ; RD50.2 v1(73.99,16.25) ; CV75.2 CV76.2 165.15,113.15 v1(164.61,112.61) ; PC810.2 200.12,57.03 199.95,56.86 v1(199.95,56.33) ; v1(17.1,108.02) R12.1 ; PC848.2 182.29,115.66 v1(181.96,115.34) ; CI17.2 v1(26,55.26) ; v1(177.89,37.95) 177.61,38.22 CE16.2 ; v1(147.92,64.53) 147.35,63.95 CD44.2 146.54,63.46 CD37.2 ; v1(157.71,108.37) 158.52,107.56 CV116.2 ; v1(194.12,63.57) 193.76,63.21 PC1302.2 ; v1(173.81,120.2) 173.42,120.6 CV146.2 ; RC70.2 RC68.2 RC69.2 90.58,97.23 90.9,96.91 91.79,96.91 92.1,97.23 92.1,97.87 v1(91.95,98.03) ; CD11.2 74.97,71.59 CD13.2 75.31,72.08 74.83,72.57 v1(74.83,72.77) ; JSPK.6 v1(72.1,20.58) ; CD48.2 153.51,72.15 153.01,71.65 CD40.2 152.18,73.16 152.55,73.54 v1(152.94,73.54) ; CC35.2 49.48,62.19 v1(49.97,61.71) ; CX9.2 217.83,165.68 218.09,165.43 v1(218.09,165.24) ; CV206.2 CV211.2 ; RV31.1 191.51,138.12 v1(191.96,138.57) ; v1(116.42,146.89) 116.87,147.33 CM46.1 ; v1(174.03,103.56) RV123.2 ; v1(18.93,11.86) 18.25,11.19 DA10.1 ; CA60.2 33.49,22.36 v1(33.68,22.55) 33.62,22.62 CA59.2 ; v1(71.91,73.35) 71.91,73.34 72.36,72.9 72.36,72.53 71.91,72.08 CD20.2 70.44,72.08 CD8.2 ; v1(26.51,97.98) 27,97.48 CX6.2 ; CG3.2 v1(76.05,40.88) ; CA29.2 66.15,25.68 v1(66.2,25.73) ; SW1.2 v1(201.17,28.16) ; CA74.2 v1(27.4,28.46) ; CM48.1 111.73,146.95 v1(111.79,146.89) ; RX33.2 v1(205.59,175.97) 205.07,176.49 CX37.2 ; CD42.2 146.28,71.65 CD46.2 146.78,72.59 v1(147.03,72.84) ; v1(186.27,107.38) 186.27,107.38 CV144.2 ; C75.1 v1(116.62,110.75) ; v1(183.88,28.59) CR7.2 ; JDB.7 211.07,51.7 v1(211.5,52.13) 211.5,52.29 211.09,52.7 JDB.8 ; v1(186.88,111.53) 186.59,111.82 CV193.2 186.95,112.77 CV155.2 ; v1(13.81,104.9) C24.2 ; CX45.2 202.34,161.81 v1(201.96,162.19) ; v1(195.99,93.93) 195.99,93.74 195.48,93.23 194.47,93.23 RV136.2 ; v1(160.11,112.72) 160.1,112.73 159.6,112.73 CV333.2 RV242.2 ; JSPK.5 v1(73.54,24.46) ; CV331.2 160.09,109.59 v1(160.07,109.6) 159.74,109.27 RV240.2 ; CR3.1 v1(180.14,16.2) ; v1(163.22,167.08) PC710.2 ; v1(74.32,65.16) 74.32,64.02 73.88,63.57 CD4.2 72.66,63.4 CD17.2 ; v1(163.99,172.54) PC709.2 ; PC109.2 v3(127.82,12.22) ; v1(171.25,104.78) 171.49,105.02 CV87.2 CV88.2 ; v1(35.78,22.08) CA64.1 ; PC853.2 174.52,120.87 v1(174.91,121.26) ; v1(169.26,172.54) 169.64,172.92 PC719.2 ; v1(34.84,26.05) RA81.1 ; CV33.2 RV17.2 200.31,111.63 v1(200.69,111.25) ; v1(189.26,27.09) CR8.2 ; v1(9.5,112.77) C8.2 ; C61.2 121.87,119.32 v1(121.58,119.02) ; CG5.2 v1(73.56,45.29) ; v1(37.68,98.55) JPWR.6 ; v1(182.75,105.26) CV213.2 ; CD29.2 v1(103.85,73.54) ; v1(73.45,39.8) 73.46,39.8 73.94,39.32 CG7.2 ; RE326.2 178.58,49.55 178.27,49.86 RE47.1 v1(177.56,50.35) ; RD52.2 v1(53.14,12.2) ; v1(190.86,32.83) CE2.2 ; CG4.2 v1(68.02,44.09) ; CD63.2 v1(53.03,15.89)
  GND1 w0.203: PBATT.10 159.57,186.87 ; PBATT.10 157.72,190.53 ; PBATT.10 157.72,188.7 ; PBATT.10 158.64,190.53 ; PBATT.10 157.72,186.87 ; PBATT.10 159.57,190.53 ; PBATT.10 159.57,188.7 ; PBATT.10 158.64,186.87 ; JODD.12 226.74,116.05 ; JODD.12 225.36,116.05 ; JODD.12 225.51,115.51 ; JODD.12 225.51,116.59 ; JODD.12 226.05,116.74 ; JODD.12 226.05,115.36 ; JHDD.1 227.94,37.39 ; JHDD.1 227.78,36.83 ; JHDD.1 227.78,37.96 ; JHDD.1 226.5,37.39 ; JHDD.1 227.22,36.67 ; JHDD.1 226.66,36.83 ; JHDD.1 226.66,37.96 ; JCRT1.17 6.98,117.33 ; JCRT1.17 6.98,118.05 ; JCRT1.17 3.62,117.33 ; JCRT1.17 6.98,118.78 ; JCRT1.17 5.3,117.33 ; JCRT1.17 3.62,118.05 ; JCRT1.17 3.62,118.78 ; JCRT1.17 5.3,118.78 ; JUSB3.4 11,25.58 ; JUSB3.4 9.43,24.9 ; JUSB3.4 11.21,24.9 ; JUSB3.4 9.64,25.58 ; JUSB3.4 10.32,24.01 ; JUSB3.4 11,24.22 ; JUSB3.4 9.64,24.22 ; JUSB3.4 10.32,25.79 ; 226.5,45.01 JHDD.7 ; JHDD.7 227.94,45.01 ; JHDD.7 227.78,45.58 ; JHDD.7 227.22,45.74 ; JHDD.7 226.66,45.58 ; JHDD.7 227.78,44.45 ; JHDD.7 226.66,44.45 ; H4.1 19.2,73.73 ; H4.1 17.86,70.56 ; H4.1 20.54,73.24 ; H4.1 17.86,73.24 ; H4.1 21.03,71.9 ; H4.1 19.2,70.07 ; H4.1 20.54,70.56 ; H4.1 17.37,71.9 ; 3,72.35 JLAN.9 ; JLAN.9 1.25,73.4 ; JLAN.9 4.75,72.35 ; JLAN.9 4.75,73.4 ; JLAN.9 1.25,72.35 ; 197.35,6.29 JREAD.23 ; JREAD.23 198.8,4.83 ; JREAD.23 197.35,7.76 ; JREAD.23 198.08,7.76 ; JREAD.23 197.35,4.83 ; JREAD.23 198.8,6.29 ; JREAD.23 198.8,7.76 ; JREAD.23 198.08,4.83 ; JUSB2.13 12.57,53.85 ; JUSB2.13 11.1,52.97 ; JUSB2.13 12.57,52.97 ; JUSB2.13 9.63,54.73 ; JUSB2.13 9.63,53.85 ; JUSB2.13 12.57,54.73 ; JUSB2.13 11.1,54.73 ; H12.1 33.03,109.4 ; H12.1 29.86,108.06 ; H12.1 31.2,107.57 ; H12.1 32.54,108.06 ; H12.1 29.86,110.74 ; H12.1 31.2,111.23 ; H12.1 32.54,110.74 ; H12.1 29.37,109.4 ; 138.59,188.7 PBATT.1 ; PBATT.1 139.52,189.63 ; PBATT.1 139.52,187.77 ; PBATT.1 138.81,189.41 ; PBATT.1 140.23,189.41 ; PBATT.1 140.45,188.7 ; PBATT.1 138.81,187.99 ; PBATT.1 140.23,187.99 ; 226.66,57.15 JHDD.13 ; JHDD.13 226.66,58.28 ; JHDD.13 227.78,58.28 ; JHDD.13 227.78,57.15 ; JHDD.13 226.5,57.71 ; JHDD.13 227.94,57.71 ; JUSB3.7 4.1,20.7 ; JUSB3.7 4.1,19.91 ; JUSB3.7 2.87,19.91 ; JUSB3.7 1.64,20.7 ; JUSB3.7 1.64,19.91 ; 12.69,41.72 JUSB2.4 ; JUSB2.4 13.47,42.5 ; JUSB2.4 11.92,42.5 ; JUSB2.4 13.29,43.1 ; JUSB2.4 12.09,41.9 ; JUSB2.4 12.09,43.1 ; JUSB2.4 12.69,43.27 ; JUSB2.4 13.29,41.9 ; JREAD.24 169.5,6.29 ; JREAD.24 169.5,7.76 ; JREAD.24 168.05,7.76 ; JREAD.24 169.5,4.83 ; JREAD.24 168.78,4.83 ; JREAD.24 168.05,4.83 ; JREAD.24 168.78,7.76 ; JREAD.24 168.05,6.29 ; JCRT1.8 6.06,106.86 ; JCRT1.8 4.88,107.38 ; JCRT1.8 5.92,107.38 ; JCRT1.8 4.88,106.34 ; JCRT1.8 5.92,106.34 ; JCRT1.8 4.74,106.86 ; JODD.7 227.6,106.39 ; JODD.7 226.5,105.29 ; JODD.7 226.34,105.84 ; JODD.7 226.5,106.39 ; JODD.7 227.76,105.84 ; JODD.7 227.05,106.55 ; JODD.7 227.6,105.29 ; 2.23,55.75 JUSB1.11 ; JUSB1.11 4.97,55.75 ; JUSB1.11 4.97,54.87 ; JUSB1.11 3.6,54.87 ; JUSB1.11 2.23,54.87 ; 226.66,64.77 JHDD.19 ; JHDD.19 226.5,65.33 ; JHDD.19 227.78,64.77 ; JHDD.19 227.94,65.33 ; JHDD.19 227.78,65.9 ; JHDD.19 226.66,65.9 ; 144.59,188.7 PBATT.4 ; PBATT.4 145.52,189.63 ; PBATT.4 146.23,187.99 ; PBATT.4 146.45,188.7 ; PBATT.4 146.23,189.41 ; PBATT.4 144.81,189.41 ; PBATT.4 144.81,187.99 ; PBATT.4 145.52,187.77 ; JUSB3.5 11.91,22 ; JUSB3.5 8.73,22 ; JUSB3.5 10.32,21.12 ; JUSB3.5 11.91,22.88 ; JUSB3.5 8.73,21.12 ; JUSB3.5 8.73,22.88 ; JUSB3.5 10.32,22.88 ; JUSB3.5 11.91,21.12 ; JHDD.24 229.7,72.4 ; JHDD.24 226.2,72.4 ; JHDD.24 227.95,70.29 ; JHDD.24 229.7,71.34 ; JHDD.24 226.2,71.34 ; JHDD.24 227.95,72.4 ; JHDD.24 229.7,70.29 ; JHDD.24 226.2,70.29 ; H6.1 206.18,94.4 ; H6.1 204.1,96.48 ; H6.1 202.58,92.88 ; H6.1 202.02,94.4 ; H6.1 205.62,95.92 ; H6.1 202.58,95.92 ; H6.1 205.62,92.88 ; H6.1 204.1,92.32 ; H9.1 225.2,170.23 ; H9.1 227.03,168.4 ; H9.1 223.86,169.74 ; H9.1 223.86,167.06 ; H9.1 226.54,167.06 ; H9.1 225.2,166.57 ; H9.1 226.54,169.74 ; H9.1 223.37,168.4 ; H33.1 142.87,130.73 ; H33.1 142.87,127.39 ; H33.1 141.2,131.35 ; H33.1 138.91,129.06 ; H33.1 139.53,127.39 ; H33.1 139.53,130.73 ; H33.1 143.49,129.06 ; H33.1 141.2,126.77 ; 4.88,110.92 JCRT1.10 ; JCRT1.10 5.92,111.96 ; JCRT1.10 5.92,110.92 ; JCRT1.10 6.06,111.44 ; JCRT1.10 4.88,111.96 ; JCRT1.10 4.74,111.44 ; 226.09,120.75 JODD.15 ; JODD.15 227.8,119.03 ; JODD.15 229.06,122.01 ; JODD.15 226.54,122.01 ; JODD.15 226.54,119.49 ; JODD.15 229.06,119.49 ; JODD.15 229.52,120.75 ; JODD.15 227.8,122.46 ; H7.1 155.38,144.5 ; H7.1 151.78,146.02 ; H7.1 154.82,146.02 ; H7.1 153.3,146.58 ; H7.1 151.78,142.98 ; H7.1 153.3,142.42 ; H7.1 154.82,142.98 ; H7.1 151.22,144.5 ; 164.2,183.57 H11.1 ; H11.1 162.86,186.74 ; H11.1 162.86,184.06 ; H11.1 166.03,185.4 ; H11.1 162.37,185.4 ; H11.1 165.54,184.06 ; H11.1 165.54,186.74 ; H11.1 164.2,187.23 ; H8.1 226.54,82.74 ; H8.1 223.37,81.4 ; H8.1 223.86,82.74 ; H8.1 226.54,80.06 ; H8.1 225.2,83.23 ; H8.1 227.03,81.4 ; H8.1 225.2,79.57 ; H8.1 223.86,80.06 ; JCRT1.16 5.3,98.68 ; JCRT1.16 3.62,98.68 ; JCRT1.16 3.62,97.23 ; JCRT1.16 6.98,97.23 ; JCRT1.16 6.98,97.95 ; JCRT1.16 3.62,97.95 ; JCRT1.16 5.3,97.23 ; JCRT1.16 6.98,98.68 ; JUSB1.13 12.57,70.57 ; JUSB1.13 9.63,72.33 ; JUSB1.13 12.57,72.33 ; JUSB1.13 11.1,70.57 ; JUSB1.13 9.63,71.45 ; JUSB1.13 11.1,72.33 ; JUSB1.13 12.57,71.45 ; 79.13,130.73 H31.1 ; H31.1 82.47,127.39 ; H31.1 83.09,129.06 ; H31.1 78.51,129.06 ; H31.1 79.13,127.39 ; H31.1 80.8,131.35 ; H31.1 80.8,126.77 ; H31.1 82.47,130.73 ; JHDD.11 227.78,55.74 ; JHDD.11 226.66,55.74 ; JHDD.11 227.78,54.61 ; JHDD.11 226.66,54.61 ; JHDD.11 226.5,55.17 ; JHDD.11 227.94,55.17 ; 17.68,39.62 H18.1 ; H18.1 19.2,36.02 ; H18.1 19.2,40.18 ; H18.1 20.72,39.62 ; H18.1 17.68,36.58 ; H18.1 17.12,38.1 ; H18.1 20.72,36.58 ; H18.1 21.28,38.1 ; JODD.14 227.8,96.16 ; JODD.14 229.06,95.71 ; JODD.14 226.54,95.71 ; JODD.14 229.06,93.19 ; JODD.14 226.09,94.45 ; JODD.14 227.8,92.73 ; JODD.14 226.54,93.19 ; JODD.14 229.52,94.45 ; 96.5,149.75 JMINI.9 ; JMINI.9 96.5,151.58 ; JMINI.9 96.74,151.58 ; JCRT1.7 6.06,104.57 ; JCRT1.7 4.88,105.09 ; JCRT1.7 4.74,104.57 ; JCRT1.7 5.92,105.09 ; JCRT1.7 4.88,104.05 ; JCRT1.7 5.92,104.05 ; JUSB1.4 13.47,60.1 ; JUSB1.4 13.29,59.5 ; JUSB1.4 11.92,60.1 ; JUSB1.4 12.69,59.32 ; JUSB1.4 13.29,60.7 ; JUSB1.4 12.09,59.5 ; JUSB1.4 12.69,60.87 ; JUSB1.4 12.09,60.7 ; 140.81,187.99 PBATT.2 ; PBATT.2 142.23,187.99 ; PBATT.2 140.59,188.7 ; PBATT.2 140.81,189.41 ; PBATT.2 142.23,189.41 ; PBATT.2 141.52,187.77 ; PBATT.2 142.45,188.7 ; PBATT.2 141.52,189.63 ; PBATT.11 137.32,186.87 ; PBATT.11 135.47,190.53 ; PBATT.11 137.32,188.7 ; PBATT.11 136.39,190.53 ; PBATT.11 137.32,190.53 ; PBATT.11 135.47,186.87 ; PBATT.11 136.39,186.87 ; PBATT.11 135.47,188.7 ; JODD.13 227.59,117.59 ; JODD.13 226.36,117.05 ; JODD.13 227.74,117.05 ; JODD.13 227.05,116.36 ; JODD.13 226.51,116.51 ; JODD.13 227.05,117.74 ; JODD.13 226.51,117.59 ; JODD.13 227.59,116.51 ; 25.4,117.58 H10.1 ; H10.1 25.4,120.63 ; H10.1 24.84,119.1 ; H10.1 28.44,120.63 ; H10.1 29,119.1 ; H10.1 26.92,117.02 ; H10.1 28.44,117.58 ; H10.1 26.92,121.18 ; H16.1 128.94,156.14 ; H16.1 125.77,154.8 ; H16.1 126.26,153.46 ; H16.1 128.94,153.46 ; H16.1 127.6,156.63 ; H16.1 126.26,156.14 ; H16.1 129.43,154.8 ; H16.1 127.6,152.97 ; JUSB1.12 4.97,71.45 ; JUSB1.12 4.97,72.33 ; JUSB1.12 2.23,72.33 ; JUSB1.12 3.6,72.33 ; JUSB1.12 2.23,71.45 ; 4.88,101.76 JCRT1.6 ; JCRT1.6 6.06,102.28 ; JCRT1.6 4.88,102.8 ; JCRT1.6 5.4,101.62 ; JCRT1.6 5.92,101.76 ; JCRT1.6 5.92,102.8 ; JCRT1.6 4.74,102.28 ; 109.2,11.57 H2.1 ; H2.1 110.54,12.06 ; H2.1 109.2,15.23 ; H2.1 107.86,12.06 ; H2.1 107.37,13.4 ; H2.1 110.54,14.74 ; H2.1 111.03,13.4 ; H2.1 107.86,14.74 ; 226.5,41.2 JHDD.4 ; JHDD.4 227.94,41.2 ; JHDD.4 227.78,40.64 ; JHDD.4 226.66,40.64 ; JHDD.4 227.78,41.77 ; JHDD.4 226.66,41.77 ; JODD.4 227.76,102.03 ; JODD.4 227.6,102.58 ; JODD.4 226.5,101.48 ; JODD.4 226.34,102.03 ; JODD.4 227.6,101.48 ; JODD.4 226.5,102.58 ; JUSB2.7 11.97,46 ; JUSB2.7 11.79,45.4 ; JUSB2.7 11.19,46.77 ; JUSB2.7 11.19,45.22 ; JUSB2.7 11.79,46.6 ; H17.1 227.03,4.9 ; H17.1 223.86,6.24 ; H17.1 226.54,3.56 ; H17.1 226.54,6.24 ; H17.1 223.37,4.9 ; H17.1 223.86,3.56 ; H17.1 225.2,3.07 ; H17.1 225.2,6.73 ; JUSB2.10 12.57,38.15 ; JUSB2.10 9.63,37.27 ; JUSB2.10 12.57,37.27 ; JUSB2.10 11.1,39.03 ; JUSB2.10 12.57,39.03 ; JUSB2.10 11.1,37.27 ; JUSB2.10 9.63,38.15 ; H34.1 83.09,103.66 ; H34.1 82.47,101.99 ; H34.1 82.47,105.33 ; H34.1 80.8,101.37 ; H34.1 78.51,103.66 ; H34.1 79.13,101.99 ; H34.1 80.8,105.95 ; H34.1 79.13,105.33 ; 138.91,103.66 H32.1 ; H32.1 142.87,101.99 ; H32.1 142.87,105.33 ; H32.1 141.2,101.37 ; H32.1 141.2,105.95 ; H32.1 139.53,101.99 ; H32.1 139.53,105.33 ; H32.1 143.49,103.66 ; JUSB3.6 11.91,34.8 ; JUSB3.6 10.32,33.92 ; JUSB3.6 8.73,35.68 ; JUSB3.6 10.32,35.68 ; JUSB3.6 8.73,34.8 ; JUSB3.6 11.91,35.68 ; JUSB3.6 8.73,33.92 ; JUSB3.6 11.91,33.92 ; JCRT1.5 5.92,113.1 ; JCRT1.5 4.88,112.06 ; JCRT1.5 4.88,113.1 ; JCRT1.5 5.4,113.24 ; JCRT1.5 5.92,112.06 ; JCRT1.5 6.06,112.58 ; JCRT1.5 4.74,112.58 ; JLAN.10 3,93.25 ; JLAN.10 1.25,93.25 ; JLAN.10 1.25,92.2 ; JLAN.10 4.75,92.2 ; JLAN.10 4.75,93.25 ; 104.5,149.75 JMINI.21 ; JMINI.21 104.5,151.58 ; JMINI.21 104.26,149.75 ; 87.27,156.76 JMINI.54 ; JMINI.54 89.18,158.32 ; JMINI.54 89.18,156.76 ; JMINI.54 87.27,158.32 ; JMINI.54 88.23,156.76 ; 2.23,54.73 JUSB2.12 ; JUSB2.12 4.97,54.73 ; JUSB2.12 4.97,53.85 ; JUSB2.12 3.6,54.73 ; JUSB2.12 2.23,53.85 ; 226.66,62.23 JHDD.17 ; JHDD.17 226.5,62.79 ; JHDD.17 227.78,62.23 ; JHDD.17 226.66,63.36 ; JHDD.17 227.78,63.36 ; JHDD.17 227.94,62.79 ; 110.1,149.75 JMINI.35 ; JMINI.35 109.86,149.75 ; JMINI.35 110.1,151.58 ; JHDD.23 229.7,36.25 ; JHDD.23 226.2,34.14 ; JHDD.23 227.95,34.14 ; JHDD.23 226.2,36.25 ; JHDD.23 226.2,35.19 ; JHDD.23 229.7,34.14 ; JHDD.23 229.7,35.19 ; JHDD.23 227.95,36.25 ; 9.63,55.75 JUSB1.10 ; JUSB1.10 9.63,54.87 ; JUSB1.10 11.1,56.63 ; JUSB1.10 12.57,54.87 ; JUSB1.10 12.57,55.75 ; JUSB1.10 12.57,56.63 ; JUSB1.10 11.1,54.87 ; JMINI.15 99.38,149.75 ; JMINI.15 98.9,149.75 ; JMINI.15 98.9,151.58 ; JMINI.15 99.38,150.67 ; JMINI.15 99.38,151.58 ; JODD.1 227.6,97.67 ; JODD.1 227.05,97.51 ; JODD.1 227.6,98.77 ; JODD.1 226.34,98.22 ; JODD.1 227.76,98.22 ; JODD.1 226.5,97.67 ; JODD.1 226.5,98.77 ; 2.23,38.15 JUSB2.11 ; JUSB2.11 2.23,37.27 ; JUSB2.11 4.97,38.15 ; JUSB2.11 3.6,37.27 ; JUSB2.11 4.97,37.27 ; 106.66,149.75 JMINI.27 ; JMINI.27 106.9,151.58 ; JMINI.27 107.38,151.58 ; 113.06,149.75 JMINI.43 ; JMINI.43 113.3,151.58 ; JMINI.43 113.3,149.75 ; 1.64,36.89 JUSB3.8 ; JUSB3.8 2.87,36.89 ; JUSB3.8 1.64,36.1 ; JUSB3.8 4.1,36.1 ; JUSB3.8 4.1,36.89 ; JMINI.53 122.93,158.32 ; JMINI.53 121.02,156.76 ; JMINI.53 121.02,158.32 ; JMINI.53 121.98,156.76 ; JMINI.53 122.93,156.76 ; 11.19,62.82 JUSB1.7 ; JUSB1.7 11.79,64.2 ; JUSB1.7 11.19,64.37 ; JUSB1.7 11.79,63 ; JUSB1.7 11.97,63.6 ; JMINI.29 107.94,151.58 ; JMINI.29 107.22,151.58 ; JMINI.29 107.7,151.58
  VCC w0.203: 12.09,41.9 JUSB2.4 ; JUSB2.4 12.09,43.1 ; JUSB2.4 12.69,41.72 ; JUSB2.4 11.92,42.5 ; JUSB2.4 13.29,43.1 ; JUSB2.4 13.29,41.9 ; JUSB2.4 12.69,43.27 ; JUSB2.4 13.47,42.5 ; JUSB2.13 12.57,53.85 ; JUSB2.13 12.57,54.73 ; JUSB2.13 9.63,54.73 ; JUSB2.13 12.57,52.97 ; JUSB2.13 11.1,54.73 ; JUSB2.12 3.6,54.73 ; JUSB2.12 2.23,54.73 ; JUSB2.12 4.97,54.73 ; JUSB3.4 11,24.22 ; JUSB3.4 10.32,25.79 ; JUSB3.4 11,25.58 ; JUSB3.4 9.64,24.22 ; JUSB3.4 9.43,24.9 ; JUSB3.4 11.21,24.9 ; JUSB3.4 10.32,24.01 ; JUSB3.4 9.64,25.58 ; 11.1,54.87 JUSB1.10 ; JUSB1.10 9.63,54.87 ; JUSB1.10 12.57,54.87 ; JUSB1.10 12.57,55.75 ; JUSB1.10 12.57,56.63 ; JUSB1.13 12.57,70.57 ; JUSB1.13 12.57,71.45 ; JUSB1.13 9.63,72.33 ; JUSB1.13 12.57,72.33 ; JUSB1.13 11.1,72.33 ; JUSB3.8 3.49,36.89 ; JUSB3.8 4.1,36.89 ; JUSB3.8 2.87,36.89 ; JUSB1.7 11.97,63.6 ; JUSB1.7 11.79,63 ; JUSB1.7 11.79,64.2 ; JCRT1.10 6.06,111.44 ; JCRT1.10 5.92,110.92 ; JCRT1.10 5.92,111.96 ; 1.64,19.91 JUSB3.7 ; JUSB3.7 2.87,19.91 ; JUSB3.7 4.1,19.91 ; 3.6,54.87 JUSB1.11 ; JUSB1.11 4.97,54.87 ; JUSB1.11 2.23,54.87 ; JUSB3.6 11.91,34.8 ; JUSB3.6 11.91,33.92 ; JUSB3.6 10.32,33.92 ; JUSB3.6 11.91,35.68 ; JUSB3.6 10.32,35.68 ; JUSB2.7 11.79,46.6 ; JUSB2.7 11.97,46 ; JUSB2.7 11.79,45.4 ; 2.23,37.27 JUSB2.11 ; JUSB2.11 4.97,37.27 ; JUSB2.11 3.6,37.27 ; JUSB2.10 12.57,37.27 ; JUSB2.10 12.57,39.03 ; JUSB2.10 11.1,37.27 ; JUSB2.10 12.57,38.15 ; JUSB2.10 9.63,37.27 ; 12.09,59.5 JUSB1.4 ; JUSB1.4 12.69,59.32 ; JUSB1.4 12.09,60.7 ; JUSB1.4 13.29,59.5 ; JUSB1.4 13.29,60.7 ; JUSB1.4 12.69,60.87 ; JUSB1.4 13.47,60.1 ; JUSB1.4 11.92,60.1 ; JCRT1.16 6.98,97.95 ; JCRT1.16 6.98,98.68 ; JCRT1.16 6.98,97.23 ; JCRT1.16 5.3,97.23 ; JCRT1.7 5.92,105.09 ; JCRT1.7 5.92,104.05 ; JCRT1.7 6.06,104.57 ; JCRT1.17 5.3,118.78 ; JCRT1.17 6.98,118.78 ; JCRT1.17 6.98,117.33 ; JCRT1.17 6.98,118.05 ; 3,72.35 JLAN.9 ; JLAN.9 4.75,72.35 ; JLAN.9 2.12,72.35 ; JCRT1.5 6.06,112.58 ; JCRT1.5 5.92,113.1 ; JCRT1.5 5.92,112.06 ; 10.32,21.12 JUSB3.5 ; JUSB3.5 11.91,22.88 ; JUSB3.5 11.91,21.12 ; JUSB3.5 10.32,22.88 ; JUSB3.5 11.91,22 ; 2.23,72.33 JUSB1.12 ; JUSB1.12 3.6,72.33 ; JUSB1.12 4.97,72.33 ; JCRT1.6 6.07,102.57 ; JCRT1.6 6.06,102.28 ; JCRT1.6 5.92,102.8 ; JCRT1.8 6.06,106.86 ; JCRT1.8 5.92,107.38 ; JCRT1.8 5.92,106.34 ; JLAN.10 3,93.25 ; JLAN.10 4.75,93.25 ; JLAN.10 3.88,93.25
  GND2 w0.203: 226.66,44.45 JHDD.7 ; JHDD.7 227.78,45.58 ; JHDD.7 226.5,45.01 ; JHDD.7 227.22,45.74 ; JHDD.7 227.78,44.45 ; JHDD.7 226.66,45.58 ; JHDD.7 227.94,45.01 ; JHDD.4 227.94,41.2 ; JHDD.4 226.66,41.77 ; JHDD.4 226.66,40.64 ; JHDD.4 226.5,41.2 ; JHDD.4 227.78,40.64 ; JHDD.4 227.78,41.77 ; H9.1 225.2,170.23 ; H9.1 223.86,169.74 ; H9.1 225.2,166.57 ; H9.1 223.37,168.4 ; H9.1 223.86,167.06 ; H9.1 226.54,167.06 ; H9.1 227.03,168.4 ; H9.1 226.54,169.74 ; 144.81,187.99 PBATT.4 ; PBATT.4 146.23,187.99 ; PBATT.4 144.81,189.41 ; PBATT.4 144.59,188.7 ; PBATT.4 145.52,189.63 ; PBATT.4 145.52,187.77 ; PBATT.4 146.23,189.41 ; PBATT.4 146.45,188.7 ; H6.1 205.62,95.92 ; H6.1 202.02,94.4 ; H6.1 206.18,94.4 ; H6.1 205.62,92.88 ; H6.1 202.58,95.92 ; H6.1 204.1,92.32 ; H6.1 202.58,92.88 ; H6.1 204.1,96.48 ; JUSB3.6 11.91,33.92 ; JUSB3.6 11.91,35.68 ; JUSB3.6 8.73,33.92 ; JUSB3.6 8.73,35.68 ; JUSB3.6 10.32,35.68 ; JUSB3.6 11.91,34.8 ; JUSB3.6 8.73,34.8 ; JUSB3.6 10.32,33.92 ; JUSB1.4 12.69,60.87 ; JUSB1.4 12.09,59.5 ; JUSB1.4 13.29,59.5 ; JUSB1.4 12.09,60.7 ; JUSB1.4 11.92,60.1 ; JUSB1.4 12.69,59.32 ; JUSB1.4 13.47,60.1 ; JUSB1.4 13.29,60.7 ; JCRT1.17 6.98,117.33 ; JCRT1.17 6.98,118.05 ; JCRT1.17 3.62,118.78 ; JCRT1.17 5.3,118.78 ; JCRT1.17 3.62,117.33 ; JCRT1.17 3.62,118.05 ; JCRT1.17 6.98,118.78 ; JCRT1.17 5.3,117.33 ; 226.2,34.14 JHDD.23 ; JHDD.23 227.95,36.25 ; JHDD.23 229.7,34.14 ; JHDD.23 226.2,36.25 ; JHDD.23 229.7,35.19 ; JHDD.23 226.2,35.19 ; JHDD.23 227.95,34.14 ; JHDD.23 229.7,36.25 ; 226.34,98.22 JODD.1 ; JODD.1 227.76,98.22 ; JODD.1 227.05,97.51 ; JODD.1 226.5,97.67 ; JODD.1 227.6,97.67 ; JODD.1 226.5,98.77 ; JODD.1 227.6,98.77 ; 9.63,38.15 JUSB2.10 ; JUSB2.10 12.57,38.15 ; JUSB2.10 12.57,39.03 ; JUSB2.10 9.63,37.27 ; JUSB2.10 11.1,37.27 ; JUSB2.10 11.1,39.03 ; JUSB2.10 12.57,37.27 ; 113.06,149.75 JMINI.43 ; JMINI.43 113.3,149.75 ; JMINI.43 113.3,151.58 ; 153.3,142.42 H7.1 ; H7.1 151.78,146.02 ; H7.1 154.82,146.02 ; H7.1 154.82,142.98 ; H7.1 153.3,146.58 ; H7.1 151.78,142.98 ; H7.1 151.22,144.5 ; H7.1 155.38,144.5 ; 136.39,186.87 PBATT.11 ; PBATT.11 137.32,186.87 ; PBATT.11 137.32,188.7 ; PBATT.11 135.47,190.53 ; PBATT.11 135.47,186.87 ; PBATT.11 137.32,190.53 ; PBATT.11 135.47,188.7 ; PBATT.11 136.39,190.53 ; JCRT1.8 5.92,106.34 ; JCRT1.8 4.88,107.38 ; JCRT1.8 4.88,106.34 ; JCRT1.8 6.06,106.86 ; JCRT1.8 4.74,106.86 ; JCRT1.8 5.92,107.38 ; H10.1 28.44,117.58 ; H10.1 28.44,120.63 ; H10.1 26.92,121.18 ; H10.1 24.84,119.1 ; H10.1 26.92,117.02 ; H10.1 25.4,120.63 ; H10.1 29,119.1 ; H10.1 25.4,117.58 ; 226.54,122.01 JODD.15 ; JODD.15 227.8,119.03 ; JODD.15 226.54,119.49 ; JODD.15 229.52,120.75 ; JODD.15 227.8,122.46 ; JODD.15 229.06,119.49 ; JODD.15 226.09,120.75 ; JODD.15 229.06,122.01 ; JUSB1.11 4.97,54.87 ; JUSB1.11 4.97,55.75 ; JUSB1.11 2.23,55.75 ; JUSB1.11 3.6,54.87 ; JUSB1.11 2.23,54.87 ; H33.1 142.87,127.39 ; H33.1 141.2,126.77 ; H33.1 143.49,129.06 ; H33.1 138.91,129.06 ; H33.1 141.2,131.35 ; H33.1 139.53,130.73 ; H33.1 142.87,130.73 ; H33.1 139.53,127.39 ; JUSB1.10 12.57,54.87 ; JUSB1.10 9.63,55.75 ; JUSB1.10 12.57,55.75 ; JUSB1.10 11.1,56.63 ; JUSB1.10 12.57,56.63 ; JUSB1.10 9.63,54.87 ; JUSB1.10 11.1,54.87 ; H16.1 128.94,156.14 ; H16.1 128.94,153.46 ; H16.1 127.6,156.63 ; H16.1 126.26,153.46 ; H16.1 127.6,152.97 ; H16.1 126.26,156.14 ; H16.1 129.43,154.8 ; H16.1 125.77,154.8 ; 226.5,65.33 JHDD.19 ; JHDD.19 227.78,65.9 ; JHDD.19 226.66,64.77 ; JHDD.19 227.78,64.77 ; JHDD.19 227.94,65.33 ; JHDD.19 226.66,65.9 ; 141.2,101.37 H32.1 ; H32.1 141.2,105.95 ; H32.1 139.53,105.33 ; H32.1 142.87,101.99 ; H32.1 143.49,103.66 ; H32.1 139.53,101.99 ; H32.1 142.87,105.33 ; H32.1 138.91,103.66 ; JLAN.10 4.75,92.2 ; JLAN.10 4.75,93.25 ; JLAN.10 1.25,93.25 ; JLAN.10 3,93.25 ; JLAN.10 1.25,92.2 ; 168.05,4.83 JREAD.24 ; JREAD.24 168.78,7.76 ; JREAD.24 168.05,7.76 ; JREAD.24 169.5,4.83 ; JREAD.24 169.5,7.76 ; JREAD.24 168.05,6.29 ; JREAD.24 169.5,6.29 ; JREAD.24 168.78,4.83 ; 107.86,14.74 H2.1 ; H2.1 107.86,12.06 ; H2.1 110.54,12.06 ; H2.1 107.37,13.4 ; H2.1 110.54,14.74 ; H2.1 111.03,13.4 ; H2.1 109.2,15.23 ; H2.1 109.2,11.57 ; 10.32,24.01 JUSB3.4 ; JUSB3.4 10.32,25.79 ; JUSB3.4 11,24.22 ; JUSB3.4 11,25.58 ; JUSB3.4 9.43,24.9 ; JUSB3.4 11.21,24.9 ; JUSB3.4 9.64,24.22 ; JUSB3.4 9.64,25.58 ; JCRT1.10 5.92,111.96 ; JCRT1.10 5.92,110.92 ; JCRT1.10 4.74,111.44 ; JCRT1.10 4.88,111.96 ; JCRT1.10 6.06,111.44 ; JCRT1.10 4.88,110.92 ; PBATT.2 141.52,189.63 ; PBATT.2 140.59,188.7 ; PBATT.2 140.81,189.41 ; PBATT.2 142.23,187.99 ; PBATT.2 140.81,187.99 ; PBATT.2 142.23,189.41 ; PBATT.2 142.45,188.7 ; PBATT.2 141.52,187.77 ; H17.1 226.54,6.24 ; H17.1 223.86,6.24 ; H17.1 226.54,3.56 ; H17.1 223.86,3.56 ; H17.1 225.2,3.07 ; H17.1 227.03,4.9 ; H17.1 225.2,6.73 ; H17.1 223.37,4.9 ; 107.22,151.58 JMINI.29 ; JMINI.29 107.7,151.58 ; JMINI.29 107.94,151.58 ; 8.73,22.88 JUSB3.5 ; JUSB3.5 8.73,22 ; JUSB3.5 11.91,22 ; JUSB3.5 8.73,21.12 ; JUSB3.5 10.32,21.12 ; JUSB3.5 11.91,21.12 ; JUSB3.5 11.91,22.88 ; JUSB3.5 10.32,22.88 ; JMINI.15 99.38,150.67 ; JMINI.15 98.9,151.58 ; JMINI.15 99.38,151.58 ; JMINI.15 99.38,149.75 ; JMINI.15 98.9,149.75 ; 1.64,36.89 JUSB3.8 ; JUSB3.8 1.64,36.1 ; JUSB3.8 2.87,36.89 ; JUSB3.8 4.1,36.89 ; JUSB3.8 4.1,36.1 ; 3.62,98.68 JCRT1.16 ; JCRT1.16 3.62,97.23 ; JCRT1.16 5.3,98.68 ; JCRT1.16 5.3,97.23 ; JCRT1.16 3.62,97.95 ; JCRT1.16 6.98,97.23 ; JCRT1.16 6.98,98.68 ; JCRT1.16 6.98,97.95 ; 78.51,103.66 H34.1 ; H34.1 82.47,105.33 ; H34.1 80.8,105.95 ; H34.1 82.47,101.99 ; H34.1 79.13,105.33 ; H34.1 80.8,101.37 ; H34.1 83.09,103.66 ; H34.1 79.13,101.99 ; JUSB1.7 11.19,64.37 ; JUSB1.7 11.79,63 ; JUSB1.7 11.97,63.6 ; JUSB1.7 11.19,62.82 ; JUSB1.7 11.79,64.2 ; 226.5,37.39 JHDD.1 ; JHDD.1 227.94,37.39 ; JHDD.1 227.78,37.96 ; JHDD.1 226.66,36.83 ; JHDD.1 226.66,37.96 ; JHDD.1 227.78,36.83 ; JHDD.1 227.22,36.67 ; JUSB2.7 11.19,46.77 ; JUSB2.7 11.97,46 ; JUSB2.7 11.79,46.6 ; JUSB2.7 11.79,45.4 ; JUSB2.7 11.19,45.22 ; JODD.7 227.6,106.39 ; JODD.7 226.5,106.39 ; JODD.7 227.05,106.55 ; JODD.7 226.34,105.84 ; JODD.7 227.76,105.84 ; JODD.7 226.5,105.29 ; JODD.7 227.6,105.29 ; 9.63,53.85 JUSB2.13 ; JUSB2.13 11.1,52.97 ; JUSB2.13 11.1,54.73 ; JUSB2.13 12.57,54.73 ; JUSB2.13 12.57,52.97 ; JUSB2.13 9.63,54.73 ; JUSB2.13 12.57,53.85 ; 164.2,183.57 H11.1 ; H11.1 165.54,184.06 ; H11.1 162.86,186.74 ; H11.1 162.86,184.06 ; H11.1 162.37,185.4 ; H11.1 166.03,185.4 ; H11.1 165.54,186.74 ; H11.1 164.2,187.23 ; 4.88,102.8 JCRT1.6 ; JCRT1.6 4.74,102.28 ; JCRT1.6 5.92,101.76 ; JCRT1.6 5.92,102.8 ; JCRT1.6 5.4,101.62 ; JCRT1.6 4.88,101.76 ; JCRT1.6 6.06,102.28 ; 4.74,112.58 JCRT1.5 ; JCRT1.5 5.92,112.06 ; JCRT1.5 4.88,113.1 ; JCRT1.5 5.4,113.24 ; JCRT1.5 5.92,113.1 ; JCRT1.5 6.06,112.58 ; JCRT1.5 4.88,112.06 ; JODD.14 227.8,96.16 ; JODD.14 229.06,95.71 ; JODD.14 229.06,93.19 ; JODD.14 226.09,94.45 ; JODD.14 226.54,95.71 ; JODD.14 229.52,94.45 ; JODD.14 226.54,93.19 ; JODD.14 227.8,92.73 ; 79.13,130.73 H31.1 ; H31.1 83.09,129.06 ; H31.1 80.8,126.77 ; H31.1 80.8,131.35 ; H31.1 78.51,129.06 ; H31.1 82.47,130.73 ; H31.1 82.47,127.39 ; H31.1 79.13,127.39 ; 157.72,186.87 PBATT.10 ; PBATT.10 157.72,190.53 ; PBATT.10 159.57,186.87 ; PBATT.10 157.72,188.7 ; PBATT.10 159.57,188.7 ; PBATT.10 159.57,190.53 ; PBATT.10 158.64,186.87 ; PBATT.10 158.64,190.53 ; H8.1 227.03,81.4 ; H8.1 225.2,79.57 ; H8.1 226.54,82.74 ; H8.1 223.86,82.74 ; H8.1 225.2,83.23 ; H8.1 223.37,81.4 ; H8.1 226.54,80.06 ; H8.1 223.86,80.06 ; JODD.13 227.74,117.05 ; JODD.13 227.05,116.36 ; JODD.13 227.05,117.74 ; JODD.13 226.51,117.59 ; JODD.13 226.51,116.51 ; JODD.13 227.59,116.51 ; JODD.13 227.59,117.59 ; JODD.13 226.36,117.05 ; JUSB2.4 13.29,43.1 ; JUSB2.4 11.92,42.5 ; JUSB2.4 12.09,43.1 ; JUSB2.4 12.69,41.72 ; JUSB2.4 13.47,42.5 ; JUSB2.4 12.09,41.9 ; JUSB2.4 13.29,41.9 ; JUSB2.4 12.69,43.27 ; JMINI.27 107.38,151.58 ; JMINI.27 106.9,151.58 ; JMINI.27 106.66,149.75 ; 138.81,189.41 PBATT.1 ; PBATT.1 139.52,187.77 ; PBATT.1 140.45,188.7 ; PBATT.1 139.52,189.63 ; PBATT.1 140.23,187.99 ; PBATT.1 138.59,188.7 ; PBATT.1 140.23,189.41 ; PBATT.1 138.81,187.99 ; 2.23,72.33 JUSB1.12 ; JUSB1.12 2.23,71.45 ; JUSB1.12 3.6,72.33 ; JUSB1.12 4.97,72.33 ; JUSB1.12 4.97,71.45 ; 2.23,53.85 JUSB2.12 ; JUSB2.12 3.6,54.73 ; JUSB2.12 4.97,53.85 ; JUSB2.12 4.97,54.73 ; JUSB2.12 2.23,54.73 ; JCRT1.7 5.92,104.05 ; JCRT1.7 5.92,105.09 ; JCRT1.7 6.06,104.57 ; JCRT1.7 4.88,104.05 ; JCRT1.7 4.88,105.09 ; JCRT1.7 4.74,104.57 ; JHDD.13 227.78,57.15 ; JHDD.13 226.5,57.71 ; JHDD.13 227.94,57.71 ; JHDD.13 226.66,57.15 ; JHDD.13 226.66,58.28 ; JHDD.13 227.78,58.28 ; H18.1 20.72,39.62 ; H18.1 17.12,38.1 ; H18.1 21.28,38.1 ; H18.1 17.68,39.62 ; H18.1 17.68,36.58 ; H18.1 19.2,40.18 ; H18.1 20.72,36.58 ; H18.1 19.2,36.02 ; JUSB1.13 12.57,71.45 ; JUSB1.13 11.1,72.33 ; JUSB1.13 11.1,70.57 ; JUSB1.13 9.63,72.33 ; JUSB1.13 12.57,72.33 ; JUSB1.13 12.57,70.57 ; JUSB1.13 9.63,71.45 ; JREAD.23 198.08,7.76 ; JREAD.23 197.35,6.29 ; JREAD.23 198.8,7.76 ; JREAD.23 198.8,6.29 ; JREAD.23 198.08,4.83 ; JREAD.23 198.8,4.83 ; JREAD.23 197.35,7.76 ; JREAD.23 197.35,4.83 ; JHDD.24 229.7,72.4 ; JHDD.24 229.7,71.34 ; JHDD.24 226.2,71.34 ; JHDD.24 226.2,70.29 ; JHDD.24 227.95,70.29 ; JHDD.24 226.2,72.4 ; JHDD.24 227.95,72.4 ; JHDD.24 229.7,70.29 ; 226.34,102.03 JODD.4 ; JODD.4 227.6,102.58 ; JODD.4 227.6,101.48 ; JODD.4 226.5,101.48 ; JODD.4 227.76,102.03 ; JODD.4 226.5,102.58 ; 121.98,156.76 JMINI.53 ; JMINI.53 121.02,158.32 ; JMINI.53 122.93,156.76 ; JMINI.53 121.02,156.76 ; JMINI.53 122.93,158.32 ; 226.66,63.36 JHDD.17 ; JHDD.17 227.78,63.36 ; JHDD.17 227.78,62.23 ; JHDD.17 226.66,62.23 ; JHDD.17 226.5,62.79 ; JHDD.17 227.94,62.79 ; 104.26,149.75 JMINI.21 ; JMINI.21 104.5,151.58 ; JMINI.21 104.5,149.75 ; 29.86,110.74 H12.1 ; H12.1 33.03,109.4 ; H12.1 31.2,107.57 ; H12.1 29.37,109.4 ; H12.1 32.54,108.06 ; H12.1 31.2,111.23 ; H12.1 32.54,110.74 ; H12.1 29.86,108.06 ; 226.66,54.61 JHDD.11 ; JHDD.11 227.78,54.61 ; JHDD.11 227.94,55.17 ; JHDD.11 227.78,55.74 ; JHDD.11 226.5,55.17 ; JHDD.11 226.66,55.74 ; JUSB2.11 4.97,37.27 ; JUSB2.11 2.23,38.15 ; JUSB2.11 2.23,37.27 ; JUSB2.11 3.6,37.27 ; JUSB2.11 4.97,38.15 ; 17.37,71.9 H4.1 ; H4.1 17.86,73.24 ; H4.1 19.2,73.73 ; H4.1 20.54,70.56 ; H4.1 21.03,71.9 ; H4.1 19.2,70.07 ; H4.1 20.54,73.24 ; H4.1 17.86,70.56 ; JODD.12 226.74,116.05 ; JODD.12 225.51,116.59 ; JODD.12 226.05,115.36 ; JODD.12 225.36,116.05 ; JODD.12 226.05,116.74 ; JODD.12 225.51,115.51 ; 1.64,19.91 JUSB3.7 ; JUSB3.7 4.1,19.91 ; JUSB3.7 4.1,20.7 ; JUSB3.7 2.87,19.91 ; JUSB3.7 1.64,20.7 ; JMINI.54 89.18,158.32 ; JMINI.54 87.27,158.32 ; JMINI.54 88.23,156.76 ; JMINI.54 89.18,156.76 ; JMINI.54 87.27,156.76 ; 110.1,149.75 JMINI.35 ; JMINI.35 110.1,151.58 ; JMINI.35 109.86,149.75 ; 1.25,72.35 JLAN.9 ; JLAN.9 4.75,72.35 ; JLAN.9 1.25,73.4 ; JLAN.9 3,72.35 ; JLAN.9 4.75,73.4 ; 96.5,149.75 JMINI.9 ; JMINI.9 96.74,151.58 ; JMINI.9 96.5,151.58
  BOTTOM w0.102: v1(66.45,19.33) v4(67.52,19.33) ; v4(42.09,95.1) v1(42.09,94.24) ; v1(37.68,98.55) v4(37.68,97.86) ; v1(209.45,164.09) v4(208.78,164.09)
  BOTTOM w0.127: v4(69.52,112.68) 68.95,112.11 v1(68.95,111.34) ; 104.57,105.27 104.32,105.03 104.32,104.75 103.95,104.38 UC1.AV43 ; 107.47,105.31 107.47,104.75 107.1,104.38 UC1.AV39 ; 105.94,105.27 105.9,105.23 105.9,104.75 105.53,104.38 UC1.AV41 ; UC1.AV36 108.68,104.38 109.05,104.75 109.05,105.16 109.17,105.27 ; UC1.AV49 100.99,104.42 100.99,104.57 101.17,104.75 101.17,105.12 101.33,105.27 ; UC1.AV46 102.38,104.38 102.75,104.75 102.75,105.01 102.73,105.03 102.73,105.34
  BOTTOM w0.152: UV1.AN6 190.46,108.47 190.86,108.08 190.86,107.5 UV1.AR5
  BOTTOM w0.178: UC1.AU28 113.88,105.21 113.9,105.23 114.18,105.23 114.2,105.21 UC1.AU26 115.12,105.21 115.14,105.23 115.43,105.23 115.44,105.21 UC1.AU24 ; UC1.AU28 112.91,105.21 112.89,105.23 112.6,105.23 112.59,105.21 UC1.AU30 ; UC1.AU28 UC1.AV28 113.39,104.08 v1(113.43,104.05) ; UC1.AU30 111.66,105.21 111.64,105.23 UC1.AU33 ; UC1.AU30 112.02,105.37 UC1.AR31 UC1.AP31 UC1.AN31 ; UC1.AV43 103.86,104.23 103.56,103.93 v1(103.54,103.93) 103.54,103.92 103.21,103.58 UC1.AW44 ; v1(116.34,105.72) 116.58,105.48 116.84,105.23 116.86,105.21 UC1.AU22 117.72,105.21 117.74,105.23 118.02,105.23 118.04,105.21 UC1.AU20 ; v1(116.34,105.72) 116.66,106.04 UC1.AR23 ; v1(116.34,105.72) 115.96,105.33 UC1.AU24 ; UC1.AN31 111.69,107.34 UC1.AN32 111.39,107.34 111.03,106.98 v1(111.03,106.94) ; UC1.AN31 UC1.AM31 UC1.AL31 112.02,109.11 v1(112.53,109.62) ; v1(117.37,102.31) 117.31,102.37 UC1.AY22 ; UC1.AV46 102.28,104.23 101.98,103.93 v1(101.97,103.93) 101.97,103.92 101.63,103.58 UC1.AW47 ; UC1.AP23 116.66,106.69 v1(116.34,107.02) 116.66,107.34 UC1.AN23 ; UC1.P63 91.16,117.63 v1(91.11,117.68) ; UC1.AU20 119.01,105.21 119.03,105.23 119.32,105.23 119.33,105.21 UC1.AU18 120.26,105.21 120.28,105.23 120.56,105.23 120.58,105.21 UC1.AU16 UC1.AV16 UC1.AW16 121.06,103.3 UC1.AY16 ; UC1.AU20 UC1.AV20 118.53,104.08 v1(118.56,104.05) ; v1(110.11,105.78) 110.37,106.04 UC1.AR33 ; v1(110.11,105.78) 109.84,105.51 UC1.AT35 109.41,105.34 109.34,105.27 108.7,105.27 108.63,105.34 UC1.AT37 107.5,105.34 107.44,105.27 107.07,105.27 107,105.34 UC1.AT40 106.01,105.34 105.94,105.27 105.18,105.27 UC1.AT42 105.04,105.34 104.97,105.27 103.61,105.27 UC1.AT43 UC1.AT46 101.9,105.27 100.85,105.27 100.81,105.31 UC1.AT49 100.35,105.33 99.66,105.33 99.54,105.21 UC1.AU51 ; v1(110.11,105.78) 110.66,105.23 UC1.AU33 ; UC1.AV34 110.58,103.91 UC1.AW33 ; UC1.AV34 110.19,104.23 v1(109.88,103.93) 109.54,103.58 UC1.AW35 ; UC1.AV34 110.58,104.56 UC1.AV33 ; UC1.AY57 95.52,102.39 v1(95.45,102.33) ; UC1.AL60 UC1.AL61 92.8,108.39 v1(92.77,108.36) ; UC1.AL60 93.93,108.88 93.94,108.9 93.94,109.18 93.93,109.2 UC1.AJ60 93.93,110.04 94.12,110.23 ; UC1.AL60 93.93,107.91 93.94,107.89 93.94,107.6 93.93,107.59 UC1.AN60 93.93,106.66 93.94,106.64 93.94,106.16 v1(93.84,106.05) ; UC1.Y59 94.25,114.71 v1(93.95,115.01) ; UC1.AU51 UC1.AV51 UC1.AW51 UC1.AY51 99.3,102.65 99.2,102.55 v1(99.2,101.64) ; UC1.AU51 98.78,105.21 98.76,105.23 98.48,105.23 98.46,105.21 UC1.AU53 97.54,105.21 97.52,105.23 97.24,105.23 97.22,105.21 UC1.AU55 ; UC1.AV33 110.88,105.2 UC1.AU33 ; UC1.AV33 110.83,104.51 UC1.AW33 ; UC1.AY26 114.61,102.31 114.42,102.12 v1(114.42,102.1) ; UC1.AN45 UC1.AN43 104.57,107.34 v1(104.84,107.07) 105.12,107.34 UC1.AN42 105.43,107.34 v1(105.76,107.02) ; UC1.AU24 UC1.AV24 UC1.AW24 UC1.AY24 115.96,102.4 v1(115.88,102.32) ; UC1.AN36 108.38,107.34 v1(108.21,107.17) ; UC1.AW33 UC1.AY33 110.83,102.68 v1(110.65,102.5) ; UC1.AV36 108.58,104.23 108.28,103.93 v1(108.27,103.93) 108.27,103.92 107.93,103.58 UC1.AW37 ; v1(112.11,102.33) 112.18,102.4 UC1.AY30 ; UC1.AJ23 117.33,109.84 v1(117.73,109.84) 117.73,110.35 UC1.AH22 ; v1(108.21,108.47) 108.38,108.64 UC1.AL36 ; UC1.AV41 105.43,104.23 105.13,103.93 v1(105.12,103.93) 105.12,103.92 104.78,103.58 UC1.AW42 ; v1(101.98,107.62) 101.65,107.34 101.43,107.34 UC1.AN48 101.16,107.08 100.78,107.08 UC1.AN49 ; v1(90.95,110.88) 91.03,110.96 UC1.AG63 UC1.AG62 UC1.AG61 UC1.AG60 94.12,110.77 94.12,110.23 ; v1(93.84,106.05) 93.98,105.91 93.98,105.53 94.28,105.23 UC1.AU59 ; v1(93.84,106.05) 93.71,105.93 UC1.AT61 92.52,105.93 UC1.AT62 92.46,105.86 91.96,105.86 91.93,105.83 91.76,105.83 UC1.AT63 91.24,105.71 90.96,105.43 90.81,105.43 v1(90.48,105.09) ; UC1.AW59 UC1.AV59 UC1.AU59 ; 94.12,110.23 94.4,109.95 UC1.AJ58 94.9,109.97 95.2,110.27 95.55,110.27 UC1.AH57 95.88,110.27 96.2,109.95 UC1.AJ56 ; UC1.AU59 94.68,105.21 94.7,105.23 94.98,105.23 95,105.21 UC1.AU57 95.92,105.21 95.94,105.23 96.23,105.23 96.24,105.21 UC1.AU55 ; v1(98.17,109.13) 98.34,109.29 UC1.AK52 98.8,109.4 UC1.AJ52 ; UC1.AY18 119.74,102.4 v1(119.67,102.34) ; v1(126.52,113.98) 126.34,113.81 UC1.AB7 ; UC1.AW50 100.13,103.74 100.21,103.74 100.4,103.92 v1(100.4,103.93) 100.41,103.93 100.67,104.2 100.77,104.2 UC1.AV49 ; UC1.AY53 97.94,103.26 97.94,102.63 97.88,102.57 97.88,102.18 v1(97.72,102.03) ; UC1.AD63 91.23,112.39 v1(91.1,112.52) ; v1(98.18,108.32) 98.51,108.65 98.69,108.65 UC1.AL52 ; v1(90.86,114.47) 91.03,114.63 UC1.Y63 ; UC1.AL17 UC1.AM17 UC1.AN17 UC1.AP17 UC1.AR17 ; UC1.AP48 101.36,106.69 101.03,106.37 ; UC1.AU55 UC1.AV55 96.73,104.08 v1(96.77,104.05) ; UC1.AH24 116.34,110.25 v1(116.34,109.62) 116.42,109.62 UC1.AK23 116.66,109.29 v1(116.33,108.97) 116.42,108.97 UC1.AL23 116.42,108.32 v1(116.34,108.32) 116.66,107.99 UC1.AM23 ; v1(90.7,106.94) 90.93,106.94 91.16,107.18 UC1.AN63 ; v1(90.73,109.27) 90.95,109.27 91.28,109.61 UC1.AJ63 ; UC1.AW40 106.36,103.58 106.69,103.92 v1(106.69,103.93) 106.71,103.93 107.01,104.23 UC1.AV39 ; UC1.AR52 98.69,106.17 98.68,106.18 98.68,106.55 98.69,106.57 UC1.AP52 UC1.AN52 ; UC1.P59 94.25,117.71 v1(93.95,118.01)
  BOTTOM w0.203: UC1.AL54 97.6,108.64 v1(97.28,108.32) ; v1(193.48,112.2) 193.36,112.09 UV1.AJ2 ; v1(129.28,111.97) 128.98,112.27 UC1.AD3 ; UC1.D2 129.63,123.56 v1(129.3,123.89) 129.29,123.88 128.85,123.88 128.8,123.93 128.45,123.93 ; UC1.AL45 103.14,108.38 v1(102.94,108.38) 102.74,108.38 UC1.AL46 ; UC1.D59 94.38,123.35 94.9,122.82 UC1.F58 ; UC1.T58 94.9,116.94 UC1.P59 ; UV1.AL2 192.49,110.46 193.37,110.46 193.41,110.42 v1(193.42,110.42) ; v1(123.12,105.86) 123.33,105.65 123.84,105.65 UC1.AR11 ; PU501.19 92.16,138.02 92.16,138.02 92.18,138.02 v1(92.18,138) ; UC1.AV14 122.37,104.23 v1(122.03,103.89) ; UC1.AU16 121.44,105.21 v1(121.76,105.53) ; PU501.29 89.02,134.67 v1(89.12,134.57) ; UC1.J63 91.19,120.63 v1(91.07,120.75) ; UC1.AG1 v1(130.79,110.85) ; UC1.V3 128.98,115.28 129.27,114.99 v1(129.27,114.94) ; UC1.AM1 v1(130.82,107.85) ; UC1.U22 v1(116.79,116.1) ; UC1.N21 118.59,118.04 118.45,117.91 118.45,117.9 118.19,117.63 117.81,117.63 117.71,117.73 UC1.P22 v1(116.79,117.73) ; v1(116.6,126.35) 116.59,126.35 116.25,126.01 UC1.A24 ; UC1.P63 UC1.P62 ; v1(119.94,109.54) 120.48,110.09 UC1.AH17 120.77,109.87 121.16,109.87 UC1.AH16 ; v1(121.76,105.53) 122.09,105.86 UC1.AR15 ; v1(121.76,105.53) 121.06,106.24 UC1.AR17 ; v1(94.1,102.38) 94.19,102.46 UC1.AY59 ; v1(92.65,113.51) 92.95,113.21 UC1.AC61 ; UC1.AW60 93.95,103.58 UC1.AW59 ; UC1.AN48 UC1.AP48 ; v1(92.65,116.51) 92.95,116.21 UC1.U61 ; UC1.AN40 106.47,107.02 UC1.AP39 ; UC1.AN40 106.08,107.34 v1(105.76,107.02) ; UC1.AN40 106.47,107.67 UC1.AN39 ; UC1.AT49 100.37,105.89 UC1.AR49 100.71,106.04 101.03,106.37 ; UC1.AG21 118.32,110.01 v1(118.44,109.89) 118.63,110.09 UC1.AH20 ; v1(25.75,102.36) 25.49,102.36 25.06,102.8 U4.36 ; UC1.AK3 128.99,109.39 129.28,109.1 v1(129.28,108.97) ; v1(92.65,119.5) 92.95,119.2 UC1.L61 ; v1(123.59,115.55) 123.59,114.6 123.72,114.46 UC1.Y10 ; UC1.AE5 127.64,111.79 v1(127.88,112.02) ; v1(130.81,116.84) UC1.T1 ; UC1.D62 91.71,123.53 UC1.D63 91.13,123.58 90.65,124.06 89.32,124.06 v1(88.61,123.35) ; v1(124.04,102.16) 123.91,102.3 UC1.AY11 ; UC1.N3 128.98,118.27 129.28,117.97 v1(129.28,117.94) ; UC1.R8 UC1.R10 ; UC1.AU1 130.53,104.9 131.13,104.3 v1(131.22,104.3) ; v1(111.08,140.33) 111.18,140.43 PU502.3 ; v1(130.79,119.84) UC1.K1 ; UC1.A48 UC1.B48 ; UC1.A56 UC1.B56 ; UC1.AW4 128.3,102.98 UC1.AY4 128.35,102.57 v1(128.49,102.43) ; UC1.AP54 97.6,106.69 v1(97.28,106.37) ; UC1.E17 120.94,122.94 v1(120.61,123.27) ; v1(92.09,136.73) 92,136.82 PU501.22 ; UC1.AM52 98.37,108.32 v1(98.18,108.32) ; UC1.AP57 95.7,106.69 v1(95.37,106.37) ; UC1.W20 119.1,115.3 v1(119.49,115.7) 119.1,116.09 UC1.U20 ; UC1.AN45 103.2,107.34 103.13,107.27 102.75,107.27 102.67,107.34 UC1.AN46 102.26,107.34 v1(101.98,107.62) ; UC1.AV8 125.14,103.93 v1(125.03,103.93) ; UC1.AT43 103.54,105.37 v1(103.89,105.72) 104.21,106.04 UC1.AR43 ; UC1.AL51 99.45,108.64 v1(99.13,108.32) ; UC1.AY6 126.9,102.48 v1(126.99,102.39) ; U2301.11 v1(96.61,31.38) ; v1(173.69,130.29) 174.09,130.29 174.09,130.3 174.31,130.3 174.7,130.69 UV1.F25 ; UC1.R22 v1(116.79,116.92) ; v1(205.07,61.41) 204.84,61.19 204.84,60.14 204.99,60 PU800.17 ; v1(121.15,102.27) 121.13,102.28 121.13,103.22 UC1.AY16 ; v1(98.22,107.69) 98.36,107.69 98.69,107.36 UC1.AN52 98.8,107.34 98.94,107.21 99.32,107.21 99.45,107.34 UC1.AN51 99.78,107.34 99.89,107.24 100.27,107.24 100.37,107.34 UC1.AN49 ; v1(113.11,110.51) UC1.AJ29 ; UC1.F61 92.95,122.2 v1(92.65,122.5)
  BOTTOM w0.229: v1(190.07,128.65) 190.08,128.67 190.08,129.51 UV1.G6 ; v1(116.54,120) 116.71,120.17 UC1.J22 ; UC1.M22 v1(116.79,118.54)
  BOTTOM w0.254: v1(208.45,174.65) JLVDS.9 ; v1(179.95,133.93) 179.86,133.84 UV1.B19 ; UC1.AJ27 114.08,109.95 UC1.AH28 113.43,109.95 UC1.AJ29 112.85,109.95 v1(112.53,109.62) ; UV1.E35 167.23,131.39 v1(167.45,131.17) 167.66,130.96 UV1.F34 UV1.F33 UV1.G33 ; v1(106.6,110.51) UC1.AJ39 ; v1(106.6,110.51) 106.19,110.51 UC1.AH40 105.82,110.14 v1(105.82,109.72) 105.53,109.72 UC1.AJ41 105.07,109.71 v1(104.77,109.71) ; v1(106.6,110.51) 107.02,110.51 UC1.AH38 107.25,109.62 v1(107.25,109.62) 106.74,109.1 UC1.AL39 106.47,108.97 UC1.AL40 106.47,108.32 v1(106.58,108.32) 106.74,108.16 UC1.AN39 UC1.AP39 UC1.AR39 ; UC1.D12 123.54,123.35 v1(123.46,123.27) 123.54,123.27 UC1.E11 ; UC1.D12 123.92,124.16 UC1.C11 ; UC1.D12 UC1.D14 122.35,124.18 UC1.C14 122.36,124.38 122.36,125.44 UC1.A14 ; UV1.R6 190.63,123.66 v1(190.94,123.66) ; v1(123.78,113.07) 124.37,113.07 UC1.AB10 ; UV1.E39 UV1.C39 164.7,132.29 164.62,132.37 v1(164.62,132.53) ; UC1.J10 124.73,120.34 v1(124.42,120.64) ; UC1.AL57 95.51,108.64 v1(95.32,108.46) ; UC1.AF18 UC1.AF17 120.97,111.81 v1(121.02,111.86) 121.2,111.86 UC1.AF15 ; v1(192.94,129.8) 192.83,129.69 UV1.G2 ; v1(114.43,106.37) 114.49,106.37 114.81,106.69 UC1.AP26 ; UV1.AP19 180.18,107.89 180.68,108.39 v1(180.82,108.39) 180.86,108.35 UV1.AP18 180.66,107.69 UV1.AR18 ; v1(219.29,172.29) 219.45,172.44 JLVDS.31 ; JLVDS.15 211.45,174.1 211.29,174.25 v1(211.29,174.44) ; v1(176.6,99.75) UV14.5 ; UC1.AH36 108.79,110.51 v1(109.21,110.51) ; UV1.B9 187.86,133.32 v1(187.76,133.42) ; UC1.AR5 127.38,106.18 127.66,105.91 v1(127.81,105.91) ; v1(175.41,105.03) 175.41,105.04 UV1.AW24 ; RP51.7 130.45,131.73 v1(130.6,131.87) ; v1(191.05,128.45) 190.89,128.29 UV1.J6 190.44,128.29 189.66,127.51 UV1.K7 ; UC1.AR39 107.14,106.37 v1(107.22,106.45) 107.4,106.45 UC1.AP38 ; UC1.AR39 106.69,106.32 UC1.AT40 ; UV1.AP17 181.66,107.9 181.99,108.23 v1(182.09,108.23) 182.12,108.23 182.46,107.89 UV1.AP16 ; v1(164.63,117.14) 164.63,117.27 165,117.64 165.22,117.64 UV1.AB39 ; v1(127.22,123.39) 126.52,123.39 126.14,123.78 UC1.D8 ; v1(183.62,105.05) 183.86,105.3 UV1.AW14 ; v1(181.85,131.2) 181.85,130.88 UV1.F17 ; UV1.F39 164.8,130.49 v1(164.71,130.58) ; UV1.AC2 192.39,116.89 192.07,116.57 v1(192.05,116.57) ; UV1.F11 186.37,130.69 v1(186.08,130.39) ; UV1.AL34 167.6,110.23 167.32,110.23 v1(167.16,110.38) ; v1(171.29,108.27) 170.87,108.69 UV1.AN30 ; v1(171.33,111.67) 171.54,111.89 UV1.AJ28 ; UC1.D54 UC1.F54 97.45,121.86 v1(97.44,121.85) ; UV1.AW30 171.06,104.98 v1(171.25,104.78) ; v1(178.4,133.88) 178.26,133.75 UV1.B21 ; UV1.AJ6 190.46,111.89 v1(190.81,111.54) ; v1(112.49,121.85) 112.49,121.86 UC1.F30 UC1.D30 ; UV1.AP30 171.31,107.45 v1(171.41,107.45) 171.66,107.69 UV1.AP29 ; UC1.AF12 123.41,111.18 UC1.AG11 ; UV1.B17 181.46,132.97 v1(181.07,133.36) ; UV1.H9 v1(188.46,128.69) 188.86,128.29 UV1.J8 ; RP41.7 143.96,111.79 v1(144.17,111.58) 143.88,111.29 RP41.8 ; v1(111.06,108.32) 110.88,108.32 UC1.AL33 ; UV1.F31 170.07,130.69 v1(170.46,130.3) ; UC1.AD21 118.59,112.48 v1(118.22,112.85) 118.09,112.98 118.09,113.03 117.67,113.45 UC1.AB22 ; v1(124.27,127.36) 124.27,126.77 123.91,126.41 UC1.A11 ; v1(104.97,121.85) 104.97,121.86 UC1.F42 UC1.D42 ; UV1.AA6 190.72,118.55 v1(190.89,118.55) ; v1(164.73,125.62) 164.8,125.69 UV1.M39 ; UC1.AG11 123.81,110.87 UC1.AF11 124.54,111.6 124.71,111.6 124.72,111.6 UC1.AE10 ; UC1.AG11 123.76,110.77 v1(123.4,110.41) ; UV1.T39 164.87,122.49 v1(164.77,122.39) ; v1(123.9,117.46) 124.04,117.32 UC1.R10 124.77,117.35 124.77,118.24 UC1.N10 ; UV1.AJ11 186.52,111.89 v1(186.88,111.53) ; UC1.AB20 119.1,113.68 119.19,113.77 119.19,113.84 119.66,114.31 v1(119.66,114.31) ; v1(186.88,111.53) 186.44,111.09 UV1.AK11 UV1.AL11 ; v1(186.88,111.53) 187.26,111.92 UV1.AJ10 ; v1(173.69,130.29) 173.29,130.69 UV1.F27 ; UC1.A52 UC1.B52 ; v1(116.79,116.1) 117.16,115.73 UC1.V23 ; UV1.AL14 183.68,110.29 v1(183.22,110.75) ; v1(130.78,113.68) 130.61,113.84 UC1.AA1 ; UC1.AH30 112.69,110.51 v1(113.11,110.51) ; UC1.L15 121.96,119.4 v1(121.58,119.02) 121.19,119.42 UC1.L17 ; v1(100.86,109.71) 100.34,109.71 100.11,109.95 UC1.AJ50 99.78,109.95 UC1.AH51 99.13,109.95 UC1.AJ52 ; v1(100.86,109.71) 100.98,109.71 101.22,109.95 UC1.AJ47 101.64,109.71 v1(101.98,109.71) ; v1(100.86,109.71) 100.86,110.16 UC1.AH49 ; v1(169.46,104.97) UV1.AW32 ; UC1.AP22 117.56,106.69 117.23,106.37 v1(117.18,106.37) ; UC1.U9 125.25,115.86 UC1.V10 ; UV1.AW35 166.96,105.42 v1(167.41,104.97) 167.86,105.42 UV1.AW34 ; UC1.L58 v1(95.45,119.43) ; UV1.AL23 176.83,110.29 v1(177.23,109.89) ; v1(175.16,133.19) 175.06,133.09 UV1.B25 ; v1(165.26,127.77) 165.26,127.77 UV1.K39 ; v1(93.95,121) 94.25,120.7 UC1.J59 ; v1(165.66,133.54) 166.06,133.13 UV1.A37 ; UV1.AM11 UV1.AN11 186.46,108.49 UV1.AP11 186.46,107.57 v1(186.27,107.38) ; UC1.C20 118.77,124.63 118.91,124.77 v1(118.91,125.09) 118.89,125.06 118.57,125.06 UC1.B20 ; v1(104.77,109.71) 104.65,109.83 UC1.AH42 ; v1(104.77,109.71) 104.24,109.71 UC1.AJ43 103.68,110.27 UC1.AH44 103.03,110.27 UC1.AJ45 102.47,109.71 v1(101.98,109.71) ; v1(179.66,130.97) 179.78,130.97 UV1.F19 ; v1(125.05,108.44) 124.97,108.44 UC1.AL10 ; v1(205.64,175.21) 205.64,174.51 205.45,174.32 JLVDS.3 ; v1(122.5,121.32) 122.58,121.32 122.9,120.99 UC1.H13 ; UC1.F58 94.9,122.01 v1(94.77,121.88) 95.19,121.46 UC1.H57 ; v1(101.98,109.71) 102.05,109.78 UC1.AH46 ; v1(207.1,175.02) 206.95,174.86 JLVDS.6 ; UV1.B15 183.04,132.71 183.04,132.91 182.97,132.98 182.97,133.11 v1(181.96,134.12) ; v1(99.95,121.85) 99.96,121.86 UC1.F50 UC1.D50 ; v1(190.93,125.3) 190.72,125.09 UV1.N6 ; UV1.AR39 165.26,107.26 v1(165.65,107.65) 165.26,108.03 UV1.AP39 165.66,108.49 UV1.AN38 ; UC1.AJ56 96.53,109.95 UC1.AH55 97.18,109.95 UC1.AJ54 97.83,109.95 UC1.AH53 98.15,109.15 v1(98.17,109.13) ; v1(126.08,118.69) 126.08,118.96 UC1.L7 ; UC1.D46 UC1.F46 102.46,121.86 v1(102.46,121.85) ; UC1.AL29 112.9,108.64 112.58,108.32 v1(112.53,108.32) ; UC1.AR52 98.51,106.04 97.95,105.48 UC1.AU53 ; UC1.AT13 123.03,105.86 v1(123.12,105.86) ; UV1.AW22 177.46,105.13 v1(177.61,104.98) ; v1(183.25,130.13) 183.26,130.15 UV1.F15 ; UC1.AP20 119.44,106.69 119.29,106.54 119.28,106.54 119.11,106.37 v1(119.09,106.37) ; v1(128.68,120.98) 128.98,121.27 UC1.G3 ; v1(129.28,105.98) 129.28,105.98 129.28,106.09 UC1.AP3 ; v1(127.88,124.96) 127.87,124.96 127.93,124.91 UC1.B4 ; UV1.AF39 165.02,114.49 164.64,114.87 v1(164.54,114.87) ; UC1.AN7 126.81,107.21 v1(126.97,107.21) ; UC1.AL17 121.55,108.98 v1(121.74,108.78) 121.74,108.99 UC1.AJ14 122.19,109.3 UC1.AL13 122.7,108.97 123,109.26 UC1.AJ13 ; UC1.B60 93.65,124.86 93.65,124.85 93.78,124.72 93.78,124.28 94.38,123.69 UC1.D59 ; v1(164.73,119.21) 164.75,119.21 164.84,119.29 UV1.Y39 ; v1(107.47,121.85) 107.48,121.86 UC1.F38 UC1.D38 ; UV1.F29 171.66,130.63 v1(171.32,130.29) ; UV1.AN27 173.31,108.69 v1(173.66,108.33) 173.26,107.94 UV1.AP27 ; UV1.AM31 170.06,109.49 v1(169.66,109.89) 169.27,110.29 UV1.AL32 UV1.AK31 ; UV1.J2 193.45,128.09 193.77,128.41 v1(193.77,128.53) ; v1(164.62,111.77) 165.1,111.29 UV1.AK39 ; v1(167.08,120.29) UV1.W34 ; UV1.V39 164.87,120.89 164.74,120.77 v1(164.73,120.77) ; RP41.6 144,112.29 v1(144.17,112.47) 143.85,112.79 RP41.5 ; v1(191.63,107.6) 191.22,107.19 UV1.AR5 ; UV1.U2 192.36,121.69 v1(192.06,121.99) ; UV3.J10 189.2,145.62 188.83,145.98 v1(188.82,145.98) ; v1(169.11,146.05) 168.71,145.65 UV5.J10 ; v1(193.31,108.77) 193.26,108.82 193.03,108.82 192.96,108.89 UV1.AN2 ; UV1.H39 164.85,128.89 v1(164.74,129) ; UV1.F9 188.06,130.69 v1(187.67,131.08) ; v1(19.52,47.76) DI4.8 DI4.3 ; UV1.AV17 181.46,105.47 v1(181.68,105.26) 181.91,105.49 UV1.AW16 ; UV1.AW20 179.06,105.07 180.11,104.02 v1(180.32,104.02) ; UC1.V58 v1(95.45,115.53) ; UV1.AL6 UV1.AK7 UV1.AL8 188.86,110.29 v1(188.48,109.92) 188.06,109.5 UV1.AM9 188.86,108.69 UV1.AN8 188.86,108.64 v1(189.25,108.26) 189.61,107.89 UV1.AP7 ; v1(120.61,123.27) 120.18,123.7 UC1.D18 119.77,124.18 UC1.C18 119.79,124.38 119.79,125.08 119.71,125.15 119.71,125.52 UC1.A18 ; UC1.A36 108.63,125.13 108.63,124.69 UC1.B36 ; UC1.L13 122.91,119.4 123.32,119 v1(123.45,119) 123.39,119.05 UC1.K12 ; UV1.AA2 192.84,118.49 v1(192.94,118.59) ; v1(176.92,131.07) 176.88,131.07 176.49,130.69 UV1.F23 ; UV1.W2 192.15,119.77 v1(192.05,119.77) ; UV1.V34 UV1.U34 ; UV1.U34 UV1.T34 167.66,122.89 v1(167.08,123.48) 167.65,123.48 UV1.R34 UV1.P34 167.54,124.41 167.54,124.97 UV1.N34 ; UV1.U34 167.13,121.89 v1(167.07,121.95) ; UV1.B29 171.86,132.71 171.67,132.9 171.67,133.51 v1(171.47,133.7) ; UV1.AE38 165.66,115.69 UV1.AD37 UV1.AD35 166.86,116.46 v1(167.03,116.63) 167.6,116.63 UV1.AC34 ; UC1.V7 125.95,115.8 v1(125.95,115.9) ; UV1.AG2 193.42,113.69 193.69,113.96 v1(193.69,113.97) ; UV1.E5 191.14,131.37 190.69,131.37 190.47,131.14 190.45,131.14 190.42,131.11 190.05,131.11 v1(189.75,131.41) 189.66,131.32 UV1.F7 ; v1(190.17,113.89) 190.46,113.6 UV1.AG6 ; v1(170.1,133.81) 170.31,133.6 170.31,132.74 UV1.B31 ; JXDP1.20 68.7,101.5 v1(68.61,101.59) ; v1(184.69,131.33) 184.69,130.87 UV1.F13 ; UV1.AV27 173.46,105.4 v1(173.83,105.03) 174.26,105.47 UV1.AW26 ; v1(189.47,133.71) 189.48,133.7 189.48,132.7 UV1.B7 ; v1(184.66,133.55) UV1.B13 ; v1(115,121.85) 115,121.86 UC1.F26 UC1.D26 ; UV7.J10 207.96,133.08 v1(208.36,132.68) ; v1(18.71,60.79) 18.6,60.91 DI1.8 DI1.3 ; UV1.N31 170.06,125.67 v1(169.75,125.99) 170.06,126.3 UV1.L31 169.65,126.9 v1(169.65,127) 169.65,127.08 UV1.K31 UV1.J31 UV1.H31 ; UC1.D5 127.7,123.82 127.73,123.82 127.82,123.91 128.43,123.91 128.45,123.93 ; v1(120.23,118.56) 120.06,118.74 UC1.L18 119.16,119.42 UC1.L20 ; v1(109.21,110.51) 109.62,110.51 UC1.AH34 109.86,109.84 v1(110.01,109.69) ; v1(109.21,110.51) UC1.AJ35 ; v1(168.73,111.6) 168.46,111.87 UV1.AJ33 ; v1(172.43,108.4) 172.14,108.69 UV1.AN29 ; v1(187.68,107.51) 188.06,107.89 UV1.AP9 UV1.AN10 ; v1(109.16,107.02) 109.22,107.02 UC1.AN35 ; v1(192.93,115.4) 192.82,115.29 UV1.AE2 ; v1(164.61,112.61) 164.82,112.61 165.11,112.89 UV1.AH39 ; v1(220.76,92.28) 220.76,92.4 220.48,92.68 220.12,92.68 220.04,92.6 PU600.8 ; v1(122.05,112.61) 122.59,112.06 UC1.AF14 ; UC4.7 71.1,104.81 v1(70.85,105.05) ; v1(190.94,116.6) 190.84,116.69 UV1.AC6 ; UC1.AL22 117.55,108.64 117.23,108.32 v1(117.18,108.32) ; UV1.L2 192.58,126.61 193.32,126.61 v1(193.46,126.75) ; v1(190.15,127.07) 190.46,126.76 UV1.L6 ; UV1.N2 193.39,124.89 v1(193.52,125.02) ; UV1.B23 v1(176.66,133.23) ; UV9.J10 207.8,112.71 208.17,113.08 v1(208.17,113.09) ; UV1.AM35 166.86,109.52 v1(167.21,109.18) 167.66,108.72 UV1.AN34 ; UV1.A3 191.91,133.25 v1(191.91,133.67) ; JXDP1.31 65.7,95.08 v1(65.43,95.34) ; UC1.D34 UC1.F34 109.99,121.86 v1(109.98,121.85) ; v1(119.94,109.54) 119.75,109.73 UC1.AH19 ; v1(125.03,106.45) 125.01,106.45 UC1.AP10 ; v1(209.95,174.63) JLVDS.12 ; UC1.A24 UC1.B24 ; UV1.W6 190.46,120.44 189.93,120.97 v1(189.93,121.21) 190.19,121.47 190.19,121.62 UV1.U6 ; v1(112.54,106.37) 112.59,106.37 UC1.AP29 ; UC1.AE58 95.42,111.63 v1(95.53,111.52) ; UC1.AA58 v1(95.45,114.23) ; v1(119.09,108.32) 119.13,108.32 119.46,108.64 UC1.AL20 ; UC1.B28 UC1.A28 ; v1(118.71,122.62) 118.77,122.62 UC1.F20 ; UV1.B11 186.28,132.7 186.28,133.67 v1(186.09,133.86) ; v1(167.1,125.14) 167.15,125.09 UV1.N34 ; RP51.5 129.45,131.75 v1(129.33,131.87) ; v1(111.04,109.62) 111.04,110.16 UC1.AH32 ; UC1.G5 127.58,121.55 126.82,121.55 UC1.G6 126.61,121.64 v1(126.27,121.3) 125.92,121.64 UC1.G8 ; UC1.AG23 117.1,110.75 v1(116.62,110.75) 116.26,110.75 116.24,110.74 116.03,110.74 115.71,110.42 UC1.AJ25 ; v1(184.5,127.26) 184.27,127.49 UV1.K14 ; UC1.A32 UC1.B32 ; UV1.Y34 167.66,119.34 v1(168.11,119.79) ; UV1.N34 UV1.M34 UV1.L34 167.66,126.77 v1(167.35,127.08) 167.66,127.39 UV1.K34 UV1.J34 167.48,128.48 167.48,128.9 UV1.H34 167.61,129.09 v1(167.16,129.54) 167.51,129.89 UV1.G34 ; UV1.AE34 167.66,115.06 v1(167.32,114.72) ; v1(168.8,133.17) 168.66,133.04 UV1.B33 ; v1(193.39,123.29) 193.37,123.3 193.1,123.3 193.08,123.29 UV1.R2 ; UV1.AN19 180.41,108.83 180.41,108.84 180.64,109.07 v1(180.85,109.07) 181.12,109.07 181.46,108.73 UV1.AN17 ; UV1.AR28 172.4,107.09 v1(172.11,107.38) 172.46,107.73 UV1.AP28 ; UC1.A40 UC1.B40 ; UV1.F21 178.08,130.69 v1(178.46,131.07) ; v1(114.41,108.29) 114.76,108.64 UC1.AL26 ; v1(173.25,133.83) 173.46,133.62 UV1.B27 ; UV1.AE6 190.02,115.09 v1(189.95,115.15) ; v1(118.22,116.1) 118.22,115.97 117.67,115.43 UC1.W22 ; UV1.P39 v1(164.76,124.09) ; JXDP1.26 67.2,97.8 67.01,97.61 65.94,97.61 65.7,97.85 JXDP1.32 ; UC1.G18 120.25,121.64 120.41,121.48 120.44,121.48 v1(120.61,121.32) 120.68,121.32 UC1.H17
  BOTTOM w0.279: JXDP1.50 61.2,100.47 v1(60.94,100.73) ; JXDP1.19 v1(68.7,95.34) ; v1(64.01,101.62) 64.01,101.57 64.2,101.38 JXDP1.38 ; JXDP1.7 71.7,91.41 72.18,90.93 v1(72.55,90.93) 73.2,91.58 JXDP1.1 ; v1(58.2,95.51) 58.7,95.01 JXDP1.59 ; JXDP1.2 73.2,101.38 v1(72.99,101.59) ; JXDP1.37 64.2,94.98 64.55,95.32 65.41,95.32 v1(65.43,95.34) ; JXDP1.14 70.2,101.57 v1(70.16,101.61) ; v1(61.56,95.01) 61.2,94.65 JXDP1.49 ; v1(71.53,101.59) 71.67,101.45 71.67,100.45 71.7,100.42 JXDP1.8 ; v1(67.27,101.61) 67.2,101.55 JXDP1.26 ; JXDP1.25 v1(67.2,95.34) ; JXDP1.13 v1(70.2,90.93)
  BOTTOM w0.305: UV9.A1 214.97,105.88 214.88,105.78 v1(214.88,105.79) ; UV5.H13 169.49,143.24 v1(169.89,142.84) ; UV5.H1 v1(169.08,152.45) ; v1(208.17,114.75) 208.17,114.71 UV9.L10 ; UV3.E14 v1(192.4,141.76) ; UV7.F5 211.93,130.71 v1(211.5,131.13) 211.88,131.51 UV7.G5 ; UV3.R12 184.39,143.98 ; 184.39,143.98 184.39,143.98 184,143.6 v1(183.98,143.6) ; 184.39,143.98 v1(183.99,144.38) UV3.R11 184.39,144.78 v1(183.99,145.18) ; 206.17,117.51 206.17,117.52 205.78,117.9 v1(205.78,117.92) ; 206.17,117.51 v1(206.57,117.91) UV9.R11 206.97,117.51 v1(207.37,117.91) ; 206.17,117.51 UV9.R12 ; UV5.A3 175.09,151.25 v1(175.48,150.85) ; UV3.E3 192.4,151.16 v1(192.01,150.77) ; UV9.C12 v1(206.57,107.51) ; UV9.M5 211.79,115.11 v1(212.18,115.5) ; v1(175.6,152.76) 175.61,152.76 175.52,152.85 UV5.A1 ; UV7.N3 v1(213.16,135.91) ; v1(208.17,109.11) 207.77,108.71 UV9.D10 ; v1(186,141.78) UV3.N14 ; v1(204.18,133.9) 204.18,133.91 UV7.K14 204.83,133.98 205.49,133.98 UV7.K13 ; v1(203.99,113.51) 203.99,113.51 UV9.K14 204.64,113.58 205.3,113.58 UV9.K13 ; UV7.E14 v1(204.13,129.91) ; v1(212.97,115.51) 213.37,115.91 UV9.N3 ; v1(203.94,107.91) UV9.C14 ; UV3.U14 v1(182.79,141.87) ; UV9.K1 v1(215.37,113.11) ; UV7.R12 206.36,137.91 ; 206.36,137.91 v1(206.76,138.31) UV7.R11 207.16,137.91 v1(207.56,138.31) ; 206.36,137.91 206.36,137.91 205.98,138.3 v1(205.98,138.32) ; UV6.J1 v1(188.79,152.38) ; UV5.B10 174.28,145.65 ; 174.28,145.65 v1(173.88,145.25) UV5.C11 ; 174.28,145.65 v1(173.88,146.05) ; v1(218.15,90.75) 218.54,90.36 PU600.4 ; UV5.C3 v1(173.88,151.65) ; UV7.N1 215.73,136.31 v1(215.73,136.31) ; v1(171.92,153.49) 171.89,153.46 UV5.E1 ; v1(211.4,106.71) 211.77,107.08 UV9.B5 ; UV3.C4 194,150.39 v1(194.39,150.78) ; v1(192.43,153.43) 192.4,153.4 UV3.E1 ; v1(212.12,114.68) 212.1,114.68 211.77,114.35 UV9.L5 ; UV7.B5 211.96,127.48 v1(211.59,127.1) ; UV6.C13 UV3.R14 184.4,141.81 v1(184.39,141.81) ; v1(195.66,141.87) 195.66,141.88 195.6,141.95 UV3.A14 ; v1(167.89,141.86) 167.89,141.87 UV5.K14 167.82,142.52 167.82,143.18 UV5.K13 ; UV10.C13 UV9.R14 v1(203.99,117.51) ; UV3.G10 v1(191.19,145.98) ; v1(213.37,119.63) 213.37,119.11 UV9.U3 ; v1(208.36,134.35) 208,134.71 UV7.L10 ; v1(175.11,141.87) 175.09,141.89 UV5.A14 ; v1(208.17,107.51) 207.77,107.11 UV9.B10 v1(207.37,107.51) UV9.C11 ; UV3.F10 191.6,145.56 v1(191.98,145.17) ; v1(194,141.76) UV3.C14 ; v1(165.88,150.85) 165.48,151.25 UV5.N3 ; UV7.G10 v1(208.36,131.11) ; v1(174.69,149.28) 174.32,149.65 UV5.B5 ; v1(207.36,109.92) 207.75,110.31 UV9.F10 ; UV5.A12 175.09,144.02 v1(174.72,143.65) ; UV7.C1 215.72,128.31 v1(215.81,128.21) ; v1(208.36,127.91) 207.96,127.51 UV7.B10 v1(207.56,127.91) 207.16,128.31 UV7.C11 ; UV9.H2 v1(214.57,111.51) ; v1(215.81,129.87) 215.77,129.91 UV7.E1 ; UV3.N12 v1(186.39,144.38) ; UV9.P10 v1(208.17,116.31) ; v1(212.97,105.91) 213.37,106.31 UV9.A3 ; UV7.C12 206.36,128.31 v1(206.76,127.91) ; UV3.R1 184.4,153.36 v1(184.39,153.36) ; v1(161.73,152.74) 162.18,152.74 UV5.U1 ; UV8.C13 UV7.R14 204.19,137.91 v1(204.19,137.91) ; v1(169.56,141.82) 169.56,142.38 UV5.H14 ; v1(186.4,150) 186.8,149.6 UV3.M5 ; UC1.V10 124.36,115.41 124.22,115.55 v1(124.14,115.55) ; UV3.H14 190.03,142.38 v1(190.42,142.77) 190.01,143.18 UV3.H13 ; v1(163.47,143.66) 163.49,143.66 163.88,144.05 UV5.R12 v1(163.48,144.45) UV5.R11 v1(163.48,145.25) ; UV7.A12 206.33,126.71 v1(205.96,127.07) ; UV9.U12 v1(206.57,118.71) ; UV7.C3 v1(213.96,127.91) ; v1(167.05,148.84) 167.09,148.88 UV5.L5 ; UV7.H13 205.55,132.31 v1(205.15,131.91) ; UV3.A1 196.03,152.78 196.12,152.69 v1(196.12,152.69) ; v1(206.76,139.11) 206.36,139.51 UV7.U12 ; UV3.G5 190.8,149.5 v1(191.17,149.13) 191.6,149.55 UV3.F5 ; UV1.AL26 174.28,110.27 174.34,110.27 v1(174.76,110.69) ; UV3.L5 187.6,149.59 187.11,149.11 v1(187.04,149.11) ; v1(215.23,140.03) 215.23,139.58 UV7.U1 ; UV9.C3 v1(213.77,107.51) ; UV9.H13 205.37,111.89 v1(204.96,111.48) 204.57,111.87 UV9.H14 ; UV9.H1 v1(214.57,112.31) ; v1(171.49,144.42) 171.5,144.42 171.88,144.05 UV5.E12 ; UV1.L11 186.71,126.69 v1(186.98,126.96) ; v1(196,150.78) 195.6,151.18 UV3.A3 ; UV7.R1 215.73,137.91 v1(215.73,137.91) ; UV1.P31 170.06,124.41 v1(169.79,124.68) 170.06,124.96 UV1.N31 ; UV3.D10 193.19,145.58 v1(192.79,145.98) ; v1(215.62,107.82) 215.53,107.91 UV9.C1 ; UV3.R3 v1(184.79,150.78) UV3.R4 v1(183.99,149.98) UV3.T5 ; UV5.D10 172.68,145.65 v1(172.28,146.05) ; UV9.C4 v1(212.97,107.51) ; UV5.H2 v1(169.88,152.45) ; UV5.M5 166.28,149.17 v1(166.23,149.12) ; UV3.K13 188.33,143.11 188.33,142.45 UV3.K14 188.4,141.8 v1(188.4,141.8) ; v1(165.08,146.05) 164.68,145.65 UV5.P10 ; v1(208.36,129.51) 207.96,129.11 UV7.D10 ; UV9.R3 v1(212.97,117.91) 212.97,117.91 UV9.R4 v1(212.17,117.91) 212.17,117.91 UV9.T5 v1(211.37,118.71) ; UC1.D21 118.09,123.14 118.61,122.62 v1(118.71,122.62) ; v1(163.48,146.05) 163.09,145.65 UV5.T10 ; UV3.C12 194,143.99 v1(194.39,144.38) ; v1(211.56,139.11) UV7.T5 v1(212.36,138.31) UV7.R4 212.76,137.91 213.16,138.31 v1(213.16,138.31) UV7.R3 ; v1(207.55,130.32) 207.94,130.71 UV7.F10 ; UV5.L10 167.09,145.69 v1(167.45,146.05) ; v1(204.18,126.68) 204.21,126.71 UV7.A14 ; UV7.H14 204.69,132.24 v1(204.13,132.24) ; UV5.K2 v1(168.28,152.45) 167.89,152.85 UV5.K1 v1(168.28,153.25) 168.68,152.85 UV4.J1 ; v1(171.5,150.84) 171.89,151.22 UV5.E3 ; v1(204.13,128.31) UV7.C14 ; UV5.F10 171.09,145.63 v1(171.47,145.24) ; UV3.P10 v1(185.6,145.98) ; UV5.U3 v1(161.76,151.25) ; v1(215.07,126.19) 215.07,126.18 215.16,126.27 UV7.A1 ; UC1.G22 118.04,121.79 v1(118.19,121.65) ; UV9.E3 213.35,109.51 v1(212.96,109.9) ; UV5.F5 171.09,149.62 v1(170.66,149.19) 170.29,149.56 UV5.G5 ; UV7.L5 211.19,134.71 v1(211.16,134.74) ; v1(194.39,145.98) 194.79,145.58 UV3.B10 v1(194.39,145.18) 194,144.79 UV3.C11 ; UV9.A12 v1(206.57,105.91) ; UV5.U12 v1(162.68,144.45) ; UV9.R1 v1(215.54,117.51) ; UV9.E1 215.58,109.51 v1(215.61,109.48) ; UV3.N1 186,153.36 v1(185.99,153.36) ; UV9.G10 v1(208.17,110.71) ; v1(204.16,136.31) UV7.N14 ; UV5.N12 v1(165.88,144.45) ; v1(173.58,153.5) 173.49,153.41 UV5.C1 ; UV5.U14 162.28,142.17 v1(162.53,141.93) ; UV7.C4 212.76,128.31 v1(213.16,127.91) ; UV5.C4 v1(173.88,150.85) ; v1(213.16,126.31) 213.56,126.71 UV7.A3 ; UV8.J1 215.16,133.11 v1(215.56,133.51) UV7.K1 215.16,133.91 v1(214.76,133.51) UV7.K2 ; UV7.U3 213.56,139.79 v1(213.33,140.03) ; UV3.K1 v1(188.79,153.18) ; UV5.M10 v1(165.88,145.25) ; UV3.M10 v1(186.39,145.18) ; v1(211.43,135.56) 211.48,135.51 UV7.M5 ; UV3.K2 188.4,151.98 v1(188.79,151.58) ; UV5.C12 v1(173.88,144.45) ; UV7.P10 v1(208.36,136.71) ; UV9.K2 214.17,113.51 v1(213.77,113.11) ; UV7.E12 206.36,129.92 206.74,130.29 v1(206.74,130.3) ; UV3.E12 192.39,143.98 192.01,144.36 v1(192,144.36) ; UV7.E3 213.54,129.91 v1(213.15,130.29) ; v1(183.19,144.38) 182.8,143.98 UV3.U12 ; UV5.E14 v1(171.89,141.82) ; UV3.T10 v1(184,145.98) ; v1(182.27,152.85) 182.73,152.85 UV3.U1 ; v1(193.39,133.11) 192.86,132.58 UV1.C1 ; UV9.A14 204.02,106.31 v1(203.99,106.28) ; UV5.R1 v1(163.88,153.42) ; UV7.U14 204.25,139.51 v1(204.25,139.53) ; UV7.H1 v1(214.76,132.71) ; UV9.U1 215.04,119.18 v1(215.04,119.63) ; UV3.H2 v1(190.39,152.38) ; UV5.N1 v1(165.48,153.42) ; v1(173.49,141.82) UV5.C14 ; UV7.H2 v1(214.76,131.91) ; UV3.A12 195.6,143.99 195.23,143.62 v1(195.23,143.58) ; UV5.G10 v1(170.68,146.05) ; UV1.W31 UV1.U31 169.73,122.02 v1(169.73,122.23) 169.73,122.56 UV1.T31 ; UV10.J1 v1(214.57,113.11) ; UV9.N1 v1(215.54,115.91) ; UV9.E12 206.17,109.52 206.55,109.9 v1(206.55,109.91) ; UV7.T10 v1(208.36,138.31) ; UV3.U3 v1(182.27,151.18) ; UV1.AL17 181.36,110.39 v1(180.87,110.39) ; UV9.G5 211.69,111.11 v1(211.31,110.74) 211.74,110.31 UV9.F5 ; UV3.L10 187.2,145.98 v1(187.16,145.98) ; v1(195.2,149.21) 194.83,149.58 UV3.B5 ; v1(165.48,141.85) UV5.N14 ; UV9.U14 v1(204.05,119.11) ; UV9.N12 v1(206.57,115.51) ; UV9.M10 v1(207.37,115.51) ; UV3.C1 194.09,152.87 v1(194.09,153.3) ; UV3.H1 v1(189.59,152.38) ; UV9.E14 v1(203.94,109.51) ; UV3.C3 v1(194.39,151.58) ; v1(162.68,149.25) UV5.T5 v1(163.48,150.05) UV5.R4 v1(164.28,150.85) 163.88,151.25 UV5.R3 ; UV9.N14 v1(203.97,115.91) ; UV4.C13 UV5.R14 v1(163.88,141.87) ; UV7.M10 v1(207.56,135.91) ; UV9.T10 v1(208.17,117.91) ; UV3.N3 v1(186.39,150.78) ; UV7.N12 v1(206.76,135.91)
  BOTTOM w0.356: JDIMM1.145 87.4,72.72 86.88,73.24 v1(86.53,73.24) 86.21,73.24 85.6,72.63 JDIMM1.139 ; JDIMM1.54 57.7,64.41 58.15,64.86 v1(58.77,64.86) 59.5,64.12 JDIMM1.60 ; JDIMM1.161 92.2,72.81 91.77,73.24 v1(90.33,73.24) 90.4,73.17 JDIMM1.155 ; JDIMM1.168 94.3,64.25 v1(94.6,64.56) 94.9,64.26 JDIMM1.170 ; JDIMM2.168 172.85,61.96 v1(172.69,61.8) 173.32,61.8 173.45,61.93 JDIMM2.170 ; JDIMM2.138 163.85,64.41 v1(163.54,64.72) 163.25,64.43 JDIMM2.136 ; JDIMM2.60 138.05,64.21 v1(137.7,64.56) ; JDIMM2.156 v1(169.25,61.86) ; JDIMM2.71 141.35,72.59 141.06,72.88 v1(140.81,72.88) 139.77,72.88 139.55,72.67 JDIMM2.65 ; JDIMM2.185 177.95,72.66 177.7,72.91 v1(176.32,72.91) 176.15,72.74 JDIMM2.179 ; JDIMM2.195 180.95,72.75 180.78,72.92 v1(180.12,72.92) 179.43,72.92 179.15,72.64 JDIMM2.189 ; JDIMM1.19 47.2,72.41 v1(46.77,72.84) 46.76,72.84 45.69,72.84 45.4,72.56 JDIMM1.13 ; v1(82.01,64.65) 82.3,64.36 JDIMM1.128 ; 131.73,72.88 131.47,72.88 131.15,72.56 JDIMM2.37 ; 131.73,72.88 v1(132.07,72.88) ; 131.73,72.88 131.73,72.88 132.68,72.88 132.95,72.61 JDIMM2.43 ; v1(44.22,73.5) 44.33,73.5 44.8,73.03 JDIMM1.11 ; JDIMM1.167 94,72.39 94.38,72.77 v1(95,72.77) 95.42,72.77 95.8,72.39 JDIMM1.173 ; JDIMM2.54 136.25,64.45 135.67,65.03 v1(134.84,65.03) 134.45,64.64 JDIMM2.48 ; JDIMM2.145 v1(165.95,72.84) 164.56,72.84 164.15,72.44 JDIMM2.139 ; v1(122.77,72.88) 123.12,72.88 123.35,72.65 JDIMM2.11 ; v1(122.77,72.88) 121.19,72.88 120.95,72.65 JDIMM2.3 ; v1(122.77,72.88) 122.75,72.86 JDIMM2.9 ; JDIMM1.14 v1(45.7,64.84) ; JDIMM1.63 60.42,71.38 60.42,70.3 60.23,70.11 59.99,70.11 59.8,70.3 JDIMM1.61 59.8,72.51 v1(59.47,72.84) ; JDIMM1.178 97.3,64.26 97.76,64.72 v1(98.45,64.72) 98.84,64.72 99.1,64.45 JDIMM1.184 ; JDIMM1.187 100,72.65 v1(99.41,73.24) ; JDIMM2.155 168.95,72.67 169.19,72.91 v1(169.45,72.91) 170.4,72.91 170.75,72.56 JDIMM2.161 ; JDIMM1.71 62.8,72.56 62.51,72.84 v1(61.88,72.84) 61.37,72.84 61,72.48 JDIMM1.65 ; 133.57,65.03 133.57,65.03 133.25,64.71 JDIMM2.44 ; 133.57,65.03 v1(133.57,65.03) ; 133.57,65.03 133.85,64.75 JDIMM2.46 ; JDIMM1.20 47.5,64.49 47.2,64.79 46.7,64.79 v1(46.7,64.81) ; JDIMM1.195 102.4,72.52 101.68,73.24 v1(101.31,73.24) 100.6,72.53 JDIMM1.189 ; v1(138.61,72.83) 138.35,72.57 JDIMM2.61 138.35,70.37 138.54,70.18 138.82,70.18 138.95,70.3 JDIMM2.63 ; JDIMM1.190 100.9,61.4 v1(100.58,61.08) ; v1(99.41,73.24) 98.21,73.24 97.6,72.63 JDIMM1.179 ; v1(99.41,73.24) 99.4,73.23 JDIMM1.185 ; JDIMM1.8 43.9,64.22 43.51,64.6 v1(43.27,64.6) 42.4,64.6 42.1,64.31 JDIMM1.2 ; JDIMM2.20 126.05,64.36 125.82,64.59 125.25,64.59 ; JDIMM2.28 128.45,62.18 128.32,62.05 127.98,62.05 127.85,62.18 JDIMM2.26 127.85,64.47 v1(127.28,65.03) ; JDIMM2.128 160.85,62.04 161.09,61.8 v1(161.6,61.8) 162.21,61.8 162.65,62.24 JDIMM2.134 ; JDIMM1.133 83.8,72.64 83.2,73.24 v1(82.39,73.24) 82,72.85 JDIMM1.127 ; JDIMM1.49 56.2,72.5 56.54,72.84 v1(57.31,72.84) 57.69,72.84 58,72.53 JDIMM1.55 ; JDIMM1.48 55.9,61.98 v1(55.66,61.73) 55.3,62.09 JDIMM1.46 ; JDIMM2.144 v1(165.65,61.86) ; JDIMM1.156 90.7,64.27 91.15,64.72 v1(91.98,64.72) 92.5,64.19 JDIMM1.162 ; JDIMM2.55 136.55,72.47 136.15,72.87 v1(135.69,72.87) 134.99,72.87 134.75,72.63 JDIMM2.49 ; v1(89.15,64.56) 88.9,64.3 JDIMM1.150 ; JDIMM2.25 127.55,72.64 127.79,72.88 128.91,72.88 v1(128.91,72.88) 129.35,72.44 JDIMM2.31 ; JDIMM1.28 49.9,64.57 v1(49.88,64.59) 49.53,64.59 49.3,64.36 JDIMM1.26 ; JDIMM1.153 89.8,72.91 89.47,73.24 v1(89.07,73.24) 89.2,73.11 JDIMM1.151 ; v1(44.22,72.84) 44.2,72.82 ; 44.2,72.82 42.62,72.82 42.4,72.61 JDIMM1.3 ; 44.2,72.82 JDIMM1.9 ; JDIMM1.172 v1(95.5,64.69) ; JDIMM2.19 125.75,72.44 v1(125.31,72.88) 124.27,72.88 123.95,72.56 JDIMM2.13 ; JDIMM2.72 141.65,64.34 141.43,64.56 v1(140.8,64.56) 140.1,64.56 139.85,64.32 JDIMM2.66 ; v1(102.64,64.71) 102.64,64.53 102.7,64.47 JDIMM1.196 ; JDIMM1.32 51.1,64.42 51.46,64.78 v1(51.85,64.78) ; JDIMM1.43 54.4,72.58 54.13,72.84 53.18,72.84 53.18,72.84 v1(52.8,72.84) 52.6,72.65 JDIMM1.37 ; JDIMM2.127 160.55,72.71 v1(160.75,72.91) 162.08,72.91 162.35,72.64 JDIMM2.133 ; JDIMM1.144 v1(87.1,64.56) ; JDIMM2.32 129.65,64.38 129.82,64.55 v1(129.82,64.57) 129.9,64.65 131.03,64.65 131.45,64.23 JDIMM2.38 ; JDIMM2.14 124.25,64.16 124.68,64.59 125.25,64.59 ; 125.25,64.59 v1(125.25,64.58) ; JDIMM1.25 49,72.6 49.24,72.84 v1(50.26,72.84) 50.38,72.84 50.8,72.43 JDIMM1.31 ; JDIMM1.138 85.3,64.37 v1(85.5,64.57) 84.84,64.57 84.7,64.43 JDIMM1.136 ; JDIMM1.66 61.3,64.28 v1(61.88,64.86) 62.69,64.86 63.1,64.45 JDIMM1.72 ; v1(53.05,61.48) 52.9,61.63 JDIMM1.38 ; v1(177.65,61.86) JDIMM2.184 ; JDIMM2.162 v1(171.05,61.86) ; JDIMM2.2 120.65,64.35 120.87,64.56 v1(121.64,64.56) 122.16,64.56 122.45,64.27 JDIMM2.8 ; JDIMM2.187 178.55,73.12 v1(178.65,73.23) ; v1(179.45,61.86) JDIMM2.190 ; JDIMM2.153 168.35,72.44 v1(167.95,72.83) 167.75,72.63 JDIMM2.151 ; JDIMM2.173 174.35,72.34 174.23,72.46 174.23,72.46 173.95,72.75 173.94,72.75 173.73,72.96 v1(173.51,72.96) 172.81,72.96 172.55,72.7 JDIMM2.167 ; JDIMM1.134 84.1,64.34 83.85,64.59 v1(83.21,64.59) ; JDIMM2.150 v1(167.45,61.86) ; JDIMM2.178 175.85,61.93 v1(175.92,61.86) 174.25,61.86 174.05,62.06 JDIMM2.172 ; JDIMM1.44 v1(54.7,61.73) ; v1(181.39,61.86) 181.25,61.99 JDIMM2.196
  BOTTOM w0.381: v1(178.96,121.36) 179.14,121.36 UV1.U20 ; UV1.AC18 180.39,116.69 v1(180.01,117.08) 179.46,117.62 UV1.AB20 ; UV1.N26 174.84,124.31 174.84,124.3 175.45,123.69 UV1.R24 175.46,123.59 v1(175.97,123.08) 176.36,122.69 UV1.T23 ; PC312.2 148.5,155.64 149.27,156.42 PR307.2 ; v1(176.95,123.03) 177.46,123.54 UV1.R22 UV1.N21 ; v1(176.96,119.32) 177.11,119.32 177.46,119.67 UV1.Y22 ; v1(174.98,120.05) 175.1,120.05 UV1.Y24 175.53,119.69 v1(175.96,119.26) ; v1(179.96,123.04) 180.12,123.04 UV1.T18 ; UV1.V21 v1(177.96,121.19) ; UV1.AD17 181.61,115.69 v1(181.96,115.34) ; UV1.R20 179.96,124.19 v1(179.96,124.28) 180.05,124.28 UV1.N18 ; UV1.Y17 v1(180.96,119.19) ; UV1.V18 180.46,120.82 v1(180.95,121.31) 181.33,121.69 UV1.U17 ; UV1.L24 UV1.M24 175.46,125.59 v1(175.89,125.17) 176.03,125.17 176.46,124.74 UV1.N23 ; v1(181.96,124.25) 182.4,124.69 UV1.N16 ; UV1.AA18 180.29,118.69 v1(179.96,118.36) ; UV1.AA16 v1(182.96,119.19) UV1.Y15 ; UV1.T31 170.05,122.89 169.98,122.95 169.98,124.03 170.05,124.09 UV1.P31 ; UV1.U27 173.46,121.83 v1(173.83,122.2) 174.33,122.69 UV1.T26 ; UV1.AG9 188.06,113.29 187.26,114.09 UV1.AF10 187.84,115.07 v1(188.06,115.07) UV1.AD9 ; UV1.J27 173.22,128.44 v1(173.63,128.44) ; v1(173.81,120.2) 174.3,120.69 UV1.V26 ; v1(182.96,122.19) 182.46,122.69 UV1.T16 ; v1(181.96,117.05) 181.46,117.55 UV1.AB17 ; v1(185.93,120.18) 186.07,120.18 186.46,120.58 UV1.V11 ; UV1.AB24 175.31,117.69 v1(174.91,118.08) 174.46,118.53 UV1.AA26 ; UV1.R15 183.46,123.67 182.98,123.19 v1(182.96,123.19) ; UV1.V23 176.96,121.19 v1(176.96,121.25) 177.4,121.69 UV1.U22 ; UV1.AF18 180.44,114.69 v1(179.95,115.17) 179.46,115.66 UV1.AD20 ; UV1.AC11 186.63,116.69 v1(186.98,116.34) ; v1(173,123.07) 173,123.21 173.46,123.67 UV1.R27 ; UV1.AA28 172.46,118.68 v1(172.94,118.2) 173.45,117.69 UV1.AB27 ; UV1.AC13 UV1.AD15 183.96,115.19 v1(183.99,115.19) ; v1(179.67,110.72) 179.24,110.29 UV1.AL20 ; UV1.AU37 166.06,106.34 v1(166.52,106.8) ; UV1.L22 177.46,126.59 v1(177.9,126.16) 177.46,125.72 UV1.M22 ; UV1.AG22 177.46,113.76 v1(177.9,114.19) 178.39,114.69 UV1.AF21 ; UV1.M17 181.52,125.69 v1(181.96,126.13) 181.46,126.63 UV1.L17 ; UV1.R17 181.46,123.56 v1(181.96,123.06) ; UV1.U24 175.34,121.69 v1(174.91,121.26) ; UV1.AB12 185.36,117.69 v1(184.91,118.14) ; UV1.U15 183.31,121.69 v1(182.89,121.27) 182.46,120.85 UV1.V16 ; UV1.T11 186.35,122.69 v1(185.87,122.21) ; UV1.AA23 176.46,118.56 v1(175.96,118.06) ; UV1.AC16 v1(182.96,117.19) UV1.AB15 ; UV1.AA21 UV1.Y20 179.48,119.69 179.93,120.14 v1(179.93,120.11) ; UV1.AD24 175.46,115.82 175.98,116.34 v1(175.98,116.34) 176.12,116.34 UV1.AC23 ; UV1.AG20 v1(178.96,113.19) UV1.AH21 ; v1(173.96,119.32) 173.83,119.32 173.46,119.68 UV1.Y27 ; v1(178.94,117.28) 178.85,117.28 178.46,116.89 UV1.AC21 ; UV1.AG17 181.58,113.69 v1(181.94,114.05) 182.46,114.57 UV1.AF16 ; UV1.AC28 UV1.AD27 173.46,115.84 v1(173.95,116.34) 174.31,116.69 UV1.AC26 ; UV1.V13 UV1.U13 184.5,121.69 v1(185.01,122.2) 184.51,122.69 UV1.T13 ; UV1.AD22 177.46,115.77 177.96,116.27 v1(177.96,116.32) ; v1(157.64,110.39) UV13.3 ; UV1.T21 v1(177.96,123.19) ; v1(177.96,118.3) 177.46,117.8 UV1.AB22
  BOTTOM w0.432: QV14.1 188.48,100.67 v1(188.75,100.4) 189.13,100.4 189.78,99.75 QV14.4
  BOTTOM w0.457: v1(209.72,162.52) UX2.3
  BOTTOM w0.508: v1(93.15,96.42) 92.68,95.95 92.68,94.31 93.24,93.74 RC24.2 93.5,93.73 RC21.2 ; PD3.1 144.07,185.01 v1(143.54,184.48) 143.16,184.1 PD1.2 ; PR602.2 221.26,91.77 221.45,91.96 v1(221.45,92.34) ; v1(141.95,23.12) 142.21,22.87 C2314.2 ; v1(60.87,87.44) 61.19,87.77 CC16.2 ; R2338.2 132.73,98.34 v1(131.36,98.34) ; v1(199.29,173.75) 198.92,174.11 RX171.2 ; CV355.2 RV41.2 v1(203.03,155.98) ; v1(200.69,111.25) 200.31,111.63 RV17.2 CV33.2 ; CE22.2 v1(47.34,106.87) ; PC106.2 126.18,19.43 v3(126.32,19.29) ; v1(195.1,101.92) 194.77,102.25 RV68.1 ; U2302.4 151.53,89.31 v1(151.71,89.13) ; v1(149.76,151.74) 149.61,151.89 PR306.2 ; CV217.2 v1(192.71,97.81) CV201.2 ; v1(204.25,163.71) 203.99,163.97 RX26.2 ; PC708.2 166.04,168.37 165.74,168.07 v1(165.74,167.27) ; v1(19.23,96.21) 19.5,96.21 19.83,96.54 C28.2 C92.2 ; PC2.2 140.68,180.99 v1(140.25,181.42) 139.79,180.96 PC1.2 ; RX35.2 197.69,172.87 198.02,173.2 v1(198.02,173.45) ; v1(82.07,136.03) 82.83,136.79 PC503.2 ; JMINI.18 103.3,146.94 v1(103.47,146.77) ; C80.2 23.27,109.86 v1(22.85,110.28) ; v1(217.33,177.56) 217.95,178.18 JLVDS.45 ; CL37.1 38.75,79.44 v1(39.21,79.89) ; QC3.3 v1(135.59,131.8) ; RV169.1 200.31,110.3 v1(200.75,109.85) ; CV113.2 v1(180.37,102.19) ; JRTC.2 212.32,39.5 212.7,39.12 v1(212.7,38.96) ; RC123.2 RC88.2 RC116.2 134.41,117.75 v1(134.45,117.7) ; R255.1 82.62,120.98 v1(82.5,121.1) ; PC803.2 207.1,62.88 v1(206.66,62.43) ; v1(199.17,37.95) 199.01,37.79 SW2.6 ; CX11.2 v1(212.49,171.28) ; v1(202.92,39.14) 202.92,39.15 SW2.1 ; v1(18.06,96.21) C90.1 C22.2 ; UL2.2 48.1,82.31 v1(48.09,82.31) ; CE25.2 44.03,100.91 v1(43.78,100.66) ; v1(94.83,146.89) 94.83,146.97 94.5,147.3 JMINI.4 ; v1(28.62,100.72) 28.16,100.26 C91.2 ; RC25.2 95.29,92.88 RC22.2 95.28,92.47 95.69,92.05 v1(95.69,91.16) ; v1(179.99,95.57) 179.86,95.44 CV85.1 ; RV15.2 206.15,100.72 v1(205.71,100.28) 205.26,100.72 CV31.2 ; JDIMM1.205 v1(38.51,55.3) ; v1(115.24,132.28) 115.24,133.89 C86.2 ; RC135.2 83.34,108.91 v1(83.02,109.23) ; C31.2 18.32,109.98 v1(17.94,110.36) 17.43,109.85 C29.2 ; CV22.2 RV5.2 200.5,134 200.88,134.38 v1(202.34,134.38) ; SW2.5 202.55,37.79 v1(202.54,37.78) ; v1(198.28,179.33) 198.28,178.7 198.53,178.45 RX170.2 ; v1(173.38,90.82) 173.19,91.01 QV25.3 ; CX35.2 196.69,170.11 196.47,170.33 v1(196.47,170.44) ; JFAN.3 v1(51.19,109.85) ; CV95.2 v1(173,101.16) 173.13,101.29 PC849.2 ; PR840.1 v1(211.22,54.7) ; CX2.2 v1(213.33,166.81) ; v1(28.67,99.88) 29.01,100.22 X1.2 ; v1(131.16,133.02) 131.04,133.13 RC84.1 ; v1(78.13,122.16) 78.13,122.76 78.79,123.42 CC28.2 ; C2327.2 159.57,86.4 v1(160.5,87.33) ; v1(202.26,35.59) SW2.2 ; CX10.2 214.48,160.67 v1(214.23,160.41) ; JREAD.21 170.96,28.92 v1(171.35,28.52) ; CC29.2 70.27,109.26 CC13.2 69.31,109.26 v1(68.61,108.56) ; PC312.2 v3(147.74,155.64) ; v1(200.94,128.98) 200.5,129.42 RV163.1 ; v1(169.57,167.65) PC707.2 ; v3(149.77,149.23) PR301.2 PC300.2 ; CV170.2 171.03,95.14 171.35,94.82 v1(171.35,94.63) ; JMINI.34 109.7,147.2 v1(110.07,146.82) ; JDIMM1.206 v1(104.12,55.3) ; v1(164.62,132.53) 164.62,133.1 164.11,133.61 163.09,133.61 162.84,133.35 CV221.2 RV147.2 ; C1.2 9.19,111.33 v1(8.79,110.93) ; v1(196.24,51.71) PC720.1 ; v1(35.59,105.47) 36.24,104.82 PC1004.2 ; v1(19.16,54.12) CI9.2 17.73,54.12 CI43.2 ; v1(88.4,129.53) 88,129.13 RC66.2 CC27.2 ; RV66.2 160.61,112.73 160.13,112.73 v1(160.11,112.72) 159.62,112.72 RV84.2 ; DI7.1 v1(15.04,26.71) ; v1(37.24,81.02) CL36.1 ; v1(193.32,42.44) 193.81,42.92 CE36.2 ; v1(36.22,117.66) PR1002.2 ; CV118.2 CV119.2 v1(187.54,101.35) 187.54,100.9 187.35,100.71 CV117.2 ; CI19.2 14.62,33.42 CI44.2 v1(14.32,34.49) ; CI40.2 20.21,63.05 CI2.2 18.01,63.05 v1(17.82,62.86) ; v1(116.42,146.89) 116.42,146.97 116.1,147.3 JMINI.50 ; JLVDS.42 228.08,177.86 228.69,177.24 v1(228.69,175.84) ; DI2.1 v1(17.09,58.07) ; v1(183.48,103.13) 184.1,102.51 CV81.2 RV95.2 183.24,101.35 RV122.2 v1(183.22,100.59) ; PC508.1 v1(89.69,142) ; UE3.7 47.53,97.17 v1(46.96,96.59) 46.26,97.29 UE3.8 ; v1(190.72,28.59) JREAD.2 ; v1(12.98,105.92) 12.68,106.22 R34.2 C4.2 ; v1(28.86,19) 28.73,18.87 CA53.2 ; PR1201.2 PC1200.2 v1(183.99,187.72) ; RV13.2 CV29.2 211.36,101.17 210.98,100.78 v1(210.98,100.59) ; RV146.2 CV220.2 164.59,128.85 v1(164.74,129) ; C5212.2 v1(84.87,117.8) ; YV1.2 169.92,98.21 169.51,98.62 v1(169.06,98.62) ; v1(218.9,168.09) RX9.2 ; CL20.2 RL31.1 35.08,78.76 v1(35.14,78.7) ; PC203.2 v1(163.67,26.11) ; C79.2 26.75,98.22 v1(26.51,97.98) ; v1(216.75,114.56) 216.82,114.56 218.58,116.33 CS13.2 ; JLVDS.41 v1(198.94,179.3) ; v1(204.78,164.22) 204.78,164.08 205.35,163.51 205.97,163.51 206.53,164.07 RX36.2 ; v1(140.97,114.95) 140.99,114.97 C2326.2 ; v1(22.63,96.07) 22.89,96.33 C30.2 ; C30.2 C21.2 ; C30.2 C46.2 ; JMINI.40 112.1,147.2 v1(111.79,146.89) ; CV172.2 172.18,95.11 v1(172.6,94.69) 173.06,95.15 CV171.2 ; v1(133.24,184.92) PQ5.3 ; RV25.1 172.37,138.19 v1(172.81,138.63) ; v1(9.44,102.36) C5.2 C2.2 R31.2 ; YV1.4 173.26,99.91 v1(173.5,100.15) ; v1(204.07,177.62) 204.95,178.5 JLVDS.43 ; v1(210.54,57.99) PR836.1 PR838.1 ; CV137.2 204.23,146.19 v1(204.5,146.45) ; UE3.5 50.07,97.36 v1(49.37,96.66) 48.8,97.23 UE3.6 ; C7.2 10.27,106.22 v1(10.7,105.79) 10.2,105.29 C6.2 ; CC17.2 61.89,102.57 v1(61.3,103.16) ; v1(155.86,156.66) v4(155.86,156.02) ; v1(186.72,138.5) 187.1,138.12 RV194.2 CV349.2 ; CX33.2 CX31.2 197.84,170.9 v1(197.35,170.42) ; v3(129.06,22.79) 129.84,22.01 v3(132.01,22.01) ; v1(128.81,95.39) 128.68,95.26 CC5.2 ; CV202.2 v1(192.69,96.92) CV216.2 ; CC30.2 62.28,106.98 v1(61.97,107.3) ; v1(160.53,115.42) 160.1,115.42 159.73,115.79 CV134.2 160.04,116.33 160.35,116.33 160.88,116.86 CV132.2 CV133.2 ; JLVDS.46 223.45,177.78 v1(223.68,177.56) ; PC210.2 v3(159.67,29.87) ; v1(23.84,115.76) 23.84,116.2 23.32,116.72 C411.2 21.73,116.72 Q4.3 ; v1(182.69,55.89) 183.24,55.34 JDIMM2.206 ; CV112.2 181,101.3 180.83,101.48 v1(180.37,101.48) 180.37,100.71 CV111.2 ; v1(158.98,182.88) PC8.2 PC7.2 ; v1(13.81,104.9) C24.2 ; v1(188.18,92.65) CV103.2 ; v1(191.96,138.57) 191.51,138.12 RV31.1 ; JDIMM2.205 v1(119.2,58) ; CL38.2 49.37,85.16 v1(49.82,84.71) ; PC202.2 v1(163.67,24.33) ; v1(84.51,140.64) 84.55,140.6 PC522.2 ; ME1.1 v1(117.33,40.16) ; PC313.2 v3(145.89,158.38) ; CV110.2 162.91,102.94 v1(163.03,102.82) ; PQ1201.3 v1(172.8,186.26) ; v1(47.21,104.98) CE23.2 ; C85.2 118.7,130.97 119.17,130.5 v1(119.17,129.5) ; RC122.2 v1(133.49,124.97) ; PC505.2 90.95,131.66 v1(90.83,131.77) ; v1(18.93,11.86) 18.93,12.35 18.19,13.09 v4(17.12,13.09) 16.34,13.09 v1(15.76,13.66) 15.37,14.06 15.37,17.19 13.55,19 v1(13.55,27.32) ; CS16.2 223.67,122.68 v1(224.46,121.89) ; CMOS1.1 111.77,40.16 v1(111.54,40.4) ; PC1214.2 172.53,184.17 PR1214.2 v1(171.61,184.86) ; RC133.1 122.25,131.46 C58.2 v1(121.39,130.82) ; v1(40.03,77.82) 39.7,78.15 YL2.2 ; RV149.2 CV224.2 195.86,105.04 v1(195.42,104.59) 195.83,104.19 CV223.2 RV148.2 ; v1(13.81,106.38) C26.2 ; v1(167.48,138.57) 167.87,138.17 RV184.2 CV399.2 ; PR204.2 v3(160.55,29.86) ; v1(183.88,28.59) JREAD.9 ; CV326.1 163.59,109.68 v1(163.73,109.82) ; CV316.2 CV304.2 219.24,104.46 v1(219.74,103.96) 220.18,103.96 221.69,105.47 CS17.2 ; CV82.2 162.4,106.75 v1(162.51,106.64) ; v1(210.6,59.95) 210.98,59.57 PR834.1 ; v1(81.98,114.31) 81.69,114.02 RC138.2 ; v1(160.3,108.15) 160.63,107.83 RV127.2 ; v1(36.6,89.79) CL19.2 ; CL15.2 33.29,79.88 v1(32.99,79.58) ; CV200.2 v1(191.48,95.82) ; v1(145.89,100.21) 145.89,99.64 146,99.53 CC1.1 ; DI5.1 v1(15.46,44.27) ; v1(198.59,64.46) 198.33,64.2 PR1304.2 PC1307.2 ; v1(40.1,104.82) PC1001.2 PR1004.2 ; v1(32.52,98.02) X1.4 ; RA29.2 v1(26.13,21.6) 26.57,22.04 RA30.2 ; RC134.2 RC101.2 124.28,94.95 v1(123.46,94.13) ; C63.2 v1(125.95,131.53) ; v1(169.62,101.92) CV94.2 ; JMINI.26 v1(106.5,149.55) ; JLVDS.44 v1(210.45,177.64) ; v1(13.1,105.29) R33.2 C3.2 ; CE24.2 v1(50.97,106.96) ; PC105.2 127.14,16.82 v3(127.41,16.55) ; RC89.2 v1(133.8,130.12) ; v1(13.81,103.38) C25.2 ; v1(46.14,109.28) JFAN.4 ; v1(174.91,100.46) RV236.2 ; v1(36.78,75.58) YL2.4 ; PR1204.2 v1(176.76,187.47) ; v1(33.37,89.66) CL41.1 ; v1(150.4,100.02) 150.4,99.45 150.08,99.13 CC2.1 ; v1(151.29,122.18) v4(150.38,122.18) ; PR1202.2 v1(182.21,187.7) ; PC1209.2 PC1203.2 174.97,183.77 PC1205.2 v1(174.21,183.78) ; v1(182.21,95.82) CV101.2 ; QV24.3 v1(176.91,90.17) ; PR106.2 v3(125.72,11.39) ; v1(180.94,95.89) CV102.2 ; PC1213.2 v1(178.22,185.82) ; v1(191.8,102.89) RV70.1 ; v1(89.83,19.82) v4(90.94,19.82) ; v1(13.81,100.96) R32.2 ; v1(53.74,109.56) JFAN.5 ; CV215.2 v1(193.89,95.82)
  vias: v1(0.51,56.34) v1(0.51,53.26) v1(0.51,21.09) v1(1.11,95.39) v1(1.11,91.45) v1(1.31,74.15) v1(1.31,70.86) v1(1.31,38.74) v1(1.31,35.71) v1(3.46,119.72) v1(5.49,93.29) v1(5.81,72.53) v1(5.93,54.81) v1(6,37.09) v1(6.3,119.89) v1(7.16,91.45) v1(7.26,74.15) v1(8.03,93.29) v1(7.98,33.83) v1(7.98,28.4) v1(7.98,22.97) v1(8.35,72.53) v1(8.47,54.81) v1(8.54,37.09) v1(8.6,106.74) v1(8.66,104.71) v1(8.79,100.52) v1(12.08,119.89) v1(17.86,119.89) v1(18.19,31.95) v1(19.97,104.46) v1(20.09,101.53) v1(21.05,110.3) v1(21.05,103) v1(21.91,96.04) v1(22.19,104.46) v1(22.25,101.53) v1(22.83,58.87) v1(22.91,62.91) v1(22.91,62.3) v1(23.52,62.91) v1(23.52,62.3) v1(23.59,75.69) v1(24.22,75.69) v1(24.16,47.13) v1(24.16,45.98) v1(24.65,58.84) v1(25.16,60.83) v1(25.16,60.22) v1(25.24,47.44) v1(25.3,49.22) v1(25.3,33.92) v1(25.3,33.28) v1(25.3,32.59) v1(25.77,60.83) v1(25.77,60.22) v1(25.94,33.98) v1(25.94,33.35) v1(25.94,32.71) v1(26.04,59.13) v1(26,19.82) v1(26.09,53.32) v1(26.09,52.72) v1(26.57,57.6) v1(26.7,53.32) v1(26.7,52.72) v1(27.08,20.65) v1(27.97,51.51) v1(27.97,50.9) v1(28.67,22.24) v1(28.83,65.57) v1(28.95,50.84) v1(29.42,65.57) v1(29.66,62.94) v1(29.66,62.33) v1(29.66,61.22) v1(29.66,60.61) v1(30,65.57) v1(31.97,101.34) v1(32.27,8.98) v1(33.37,103.63) v1(33.43,101.03) v1(35.14,78.08) v1(35.78,73.14) v1(36.16,114.49) v1(36.16,112.77) v1(36.8,114.49) v1(36.8,112.77) v1(36.8,85.16) v1(36.8,84.27) v1(36.8,83.32) v1(37,118.39) v1(37.49,114.49) v1(37.53,8.98) v1(37.75,85.16) v1(37.75,84.27) v1(37.75,83.39) v1(38.53,119.89) v1(38.57,101.67) v1(38.64,85.16) v1(38.64,84.27) v1(38.64,83.32) v1(40.92,81.47) v1(41.27,8.98) v1(41.61,88.91) v1(41.56,81.47) v1(42.19,68.68) v1(42.19,67.16) v1(42.51,114.17) v1(42.51,113.03) v1(43.15,114.17) v1(43.15,113.03) v1(43.27,60.7) v1(43.27,59.17) v1(43.46,114.81) v1(44.22,68.68) v1(44.86,58.79) v1(46.53,8.98) v1(46.63,68.68) v1(46.63,67.16) v1(46.57,60.7) v1(46.57,59.17) v1(48,119.89) v1(49.04,69.06) v1(49.04,66.78) v1(49.11,60.7) v1(49.11,59.17) v1(50.31,68.85) v1(50.31,67.32) v1(50.27,8.98) v1(51.53,60.7) v1(51.53,59.17) v1(52.9,68.65) v1(52.9,67.13) v1(52.9,65.6) v1(53.61,120.31) v1(54.7,69.06) v1(54.7,66.78) v1(55.53,8.98) v1(56.87,68.68) v1(56.87,67.16) v1(56.86,65.54) v1(58.77,60.7) v1(58.77,59.17) v1(59.1,121.57) v1(59.47,68.68) v1(59.47,67.16) v1(60.15,61.08) v1(60.15,58.79) v1(61.88,68.68) v1(61.88,67.16) v1(61.88,60.7) v1(61.88,59.17) v1(62.4,12.98) v1(62.51,120.03) v1(64.04,73.86) v1(64.04,73.04) v1(64.33,123.63) v1(64.42,120.03) v1(64.42,74.31) v1(64.86,74.75) v1(65.31,75.19) v1(67.6,12.98) v1(69.2,126.45) v1(71.83,41.65) v1(72.8,12.98) v1(73.59,129.97) v1(74.53,37.35) v1(76.44,53.45) v1(77.41,134.11) v1(78,12.98) v1(79.59,134.85) v1(82.79,68.7) v1(82.79,67.17) v1(83.19,144.42) v1(83.2,12.98) v1(83.44,60.7) v1(83.44,59.17) v1(83.7,142.17) v1(84.74,69.08) v1(84.74,66.79) v1(84.93,150.8) v1(85.3,60.7) v1(85.3,59.17) v1(85.51,157.4) v1(86.53,68.7) v1(86.53,67.17) v1(87.04,115.78) v1(86.96,17.49) v1(86.96,14.95) v1(87.64,60.7) v1(87.64,59.17) v1(88.02,106.24) v1(87.97,102.68) v1(88.19,107.66) v1(88.4,12.98) v1(88.55,138.19) v1(88.55,136.98) v1(88.61,29.6) v1(88.76,103.57) v1(88.96,120.23) v1(88.97,114.37) v1(89.03,105.92) v1(89.07,68.7) v1(89.07,67.17) v1(89.06,29.98) v1(89.25,137.55) v1(89.15,61.08) v1(89.15,58.79) v1(89.26,121.75) v1(89.42,159.3) v1(89.42,153.52) v1(89.95,138.19) v1(89.95,136.98) v1(89.9,8.98) v1(90.59,68.7) v1(90.59,67.17) v1(91.15,16.86) v1(91.15,14.32) v1(91.15,11.78) v1(91.26,60.7) v1(91.26,59.17) v1(91.46,99.44) v1(92.42,68.7) v1(92.42,67.17) v1(92.76,100.87) v1(92.8,28.14) v1(92.8,27.56) v1(93.25,99.35) v1(94.25,60.7) v1(94.25,59.17) v1(94.53,97.8) v1(94.56,128.12) v1(94.57,100.64) v1(94.87,69.08) v1(94.87,66.79) v1(95.22,8.98) v1(95.91,99.18) v1(95.85,29.41) v1(96.25,60.7) v1(96.25,59.17) v1(96.23,16.86) v1(96.23,14.32) v1(96.23,11.78) v1(96.36,124.08) v1(96.51,68.7) v1(96.51,67.17) v1(96.61,29.41) v1(96.77,127.63) v1(97.29,100.56) v1(97.37,29.41) v1(98.52,136.41) v1(98.58,132.85) v1(99.03,60.7) v1(99.03,59.17) v1(99.34,130.79) v1(99.34,128.84) v1(99.41,68.7) v1(99.41,67.17) v1(99.53,136.41) v1(99.66,132.85) v1(99.72,94.79) v1(100.23,95.06) v1(100.23,28.65) v1(100.23,28.06) v1(100.55,8.98) v1(100.58,58.79) v1(100.86,130.73) v1(100.86,128.82) v1(101.31,68.7) v1(101.31,67.17) v1(101.31,16.86) v1(101.31,14.32) v1(101.31,11.78) v1(101.82,138.63) v1(101.82,136.41) v1(101.95,132.85) v1(101.98,60.7) v1(101.98,59.17) v1(102.57,30.11) v1(102.71,128.83) v1(102.9,138.63) v1(102.9,136.41) v1(103.03,132.85) v1(103.15,95.04) v1(103.15,94.43) v1(103.22,65.48) v1(103.22,64.84) v1(103.15,30.11) v1(103.55,102.6) v1(103.98,74.18) v1(104.74,95.01) v1(104.74,94.4) v1(105.12,138.63) v1(105.12,136.41) v1(105.11,102.6) v1(105.25,132.85) v1(105.44,127.84) v1(105.59,128.6) v1(106.2,136.41) v1(106.33,132.85) v1(106.79,100.49) v1(108.49,136.41) v1(108.46,101.42) v1(109.57,138.57) v1(109.57,136.41) v1(109.57,132.79) v1(109.86,98.94) v1(111.42,127.59) v1(111.43,125.69) v1(111.85,138.57) v1(111.85,136.41) v1(111.92,132.79) v1(111.96,99.67) v1(111.96,98.37) v1(111.96,95.75) v1(112.93,138.57) v1(112.93,136.41) v1(112.99,128.41) v1(112.99,126.48) v1(113.58,99.02) v1(113.58,96.42) v1(113.97,126.97) v1(115.67,99.67) v1(115.67,97.72) v1(116.07,95.33) v1(116.28,129.52) v1(116.26,127.54) v1(116.46,124.08) v1(116.51,8.98) v1(117.57,99.99) v1(117.57,98.31) v1(119.17,127.59) v1(119.17,99.02) v1(120.74,159.29) v1(120.74,153.52) v1(120.74,68.72) v1(120.74,67.2) v1(121.05,99.09) v1(121.05,97.03) v1(121.75,128.82) v1(121.82,60.74) v1(121.82,59.21) v1(121.83,8.98) v1(122.77,68.72) v1(122.77,67.2) v1(123.41,61.12) v1(123.41,58.83) v1(123.54,134.77) v1(123.54,134.19) v1(123.47,132.85) v1(124.04,132.85) v1(124.99,100.79) v1(125.12,60.74) v1(125.12,59.21) v1(125.31,68.72) v1(125.31,67.2) v1(126,189.6) v1(126,183.84) v1(126,178.08) v1(126,172.32) v1(126,166.56) v1(126,160.8) v1(127.25,134.88) v1(127.22,134.25) v1(127.15,8.98) v1(127.66,60.74) v1(127.66,59.21) v1(127.98,69.1) v1(127.98,66.82) v1(129.1,101.17) v1(129.38,68.72) v1(129.38,67.2) v1(130.06,175.91) v1(130.2,60.74) v1(130.2,59.21) v1(132.07,68.8) v1(132.07,67.28) v1(132.47,8.98) v1(132.74,60.74) v1(132.74,59.21) v1(133.6,69.18) v1(133.6,66.9) v1(133.8,189.6) v1(135.03,60.74) v1(135.03,59.21) v1(135.1,109.46) v1(135.22,190.6) v1(135.73,68.8) v1(135.73,67.28) v1(136.5,94.95) v1(136.79,114.97) v1(137.14,94.95) v1(137.32,60.74) v1(137.32,59.21) v1(137.79,8.98) v1(138.3,68.72) v1(138.3,67.2) v1(138.7,61.12) v1(138.7,58.83) v1(140.81,68.72) v1(140.81,67.2) v1(140.81,60.74) v1(140.81,59.21) v1(141.38,190.6) v1(143.12,8.98) v1(143.35,30.49) v1(143.35,29.86) v1(144.49,164.48) v1(144.56,165.49) v1(146.33,151.33) v1(146.4,149.74) v1(147.55,190.6) v1(148.44,8.98) v1(153.31,120.03) v1(153.72,190.6) v1(153.76,8.98) v1(154.65,79.89) v1(154.78,132.28) v1(154.78,131.65) v1(155.01,119.77) v1(155.06,79.48) v1(155.41,132.92) v1(155.41,132.28) v1(155.41,131.65) v1(155.54,79.07) v1(155.86,157.3) v1(155.95,78.65) v1(156.3,107.76) v1(156.42,118.21) v1(156.49,157.93) v1(156.49,157.3) v1(156.76,119.77) v1(158.18,118.21) v1(158.7,79.88) v1(159.08,8.98) v1(159.17,79.4) v1(159.59,78.99) v1(159.88,190.6) v1(160.03,78.54) v1(161.24,68.99) v1(161.24,67.47) v1(161.24,65.94) v1(163.03,69.37) v1(163.03,67.09) v1(164.4,8.98) v1(164.61,158.2) v1(165.25,158.2) v1(165.48,68.99) v1(165.48,67.47) v1(165.48,65.94) v1(165.89,158.23) v1(165.9,0.5) v1(167.03,2.49) v1(167.1,172.54) v1(167.17,7.03) v1(167.42,172.03) v1(167.35,170) v1(167.35,168.86) v1(167.76,68.99) v1(167.76,67.47) v1(167.76,65.94) v1(167.92,169.43) v1(168.32,158.24) v1(168.46,32.76) v1(168.56,170) v1(168.56,168.92) v1(168.95,158.24) v1(169.07,67.85) v1(169.07,65.56) v1(169.59,158.24) v1(170.34,68.99) v1(170.34,67.47) v1(170.34,65.94) v1(171.24,0.5) v1(171.35,2.49) v1(171.49,7.03) v1(171.76,189.6) v1(172.63,68.99) v1(172.63,67.47) v1(172.63,65.94) v1(173.13,38.87) v1(173.64,37.39) v1(173.89,69.38) v1(173.9,67.09) v1(174.22,51.14) v1(175.61,31.32) v1(176.11,40.21) v1(176.24,31.32) v1(176.34,68.99) v1(176.34,67.47) v1(176.34,65.94) v1(176.37,24.14) v1(176.37,22.74) v1(176.43,2.49) v1(176.57,7.03) v1(176.57,0.5) v1(176.88,31.32) v1(176.98,189.6) v1(177.07,23.44) v1(177.51,31.32) v1(177.7,22.74) v1(177.77,24.14) v1(178.62,68.99) v1(178.62,67.47) v1(178.62,65.94) v1(179.93,67.85) v1(179.93,65.56) v1(180.12,74.13) v1(180.12,73.54) v1(180.89,158.24) v1(181.2,68.99) v1(181.2,67.47) v1(181.2,65.94) v1(181.52,158.24) v1(181.51,2.49) v1(181.65,7.03) v1(181.9,0.5) v1(182.21,189.6) v1(182.16,158.24) v1(184.33,158.24) v1(184.97,158.24) v1(185.07,76.91) v1(185.39,43.83) v1(185.6,158.24) v1(185.77,41.79) v1(186.34,60.63) v1(186.3,58.84) v1(186.4,172.98) v1(186.4,172.29) v1(186.4,171.59) v1(186.59,2.49) v1(186.73,7.03) v1(187.04,43.06) v1(187.16,40.65) v1(187.23,0.5) v1(187.44,189.6) v1(188.87,186.26) v1(188.87,176.16) v1(189.45,186.26) v1(189.45,176.16) v1(190.52,176.16) v1(190.58,186.26) v1(191.1,176.16) v1(191.16,186.26) v1(191.55,157.87) v1(191.67,2.49) v1(191.81,7.03) v1(192.18,157.87) v1(192.5,61.1) v1(192.5,60.4) v1(192.57,0.5) v1(192.67,189.6) v1(192.82,157.87) v1(193.25,70.88) v1(193.69,80.15) v1(193.83,70.88) v1(194.07,79.45) v1(194.12,64.4) v1(194.28,91.81) v1(194.52,80.15) v1(194.66,64.02) v1(194.86,91.81) v1(194.9,79.45) v1(195.22,70.88) v1(195.34,80.15) v1(195.36,64.4) v1(195.36,63.51) v1(195.72,79.45) v1(195.8,70.88) v1(196.17,80.15) v1(196.31,91.81) v1(196.55,79.45) v1(196.75,3.76) v1(196.75,2.49) v1(196.89,91.81) v1(196.89,7.03) v1(196.99,80.15) v1(196.99,70.88) v1(197.37,79.45) v1(197.58,70.88) v1(197.82,80.15) v1(197.9,189.6) v1(197.9,182.1) v1(197.91,91.81) v1(197.9,0.5) v1(198.2,79.45) v1(198.59,70.88) v1(198.82,80.2) v1(199.06,79.58) v1(199.05,78.5) v1(200.3,81.07) v1(200.32,33.78) v1(200.49,32.67) v1(201.2,81.1) v1(201.83,3.76) v1(201.83,2.49) v1(202.09,81.1) v1(202.9,168.81) v1(202.94,55.51) v1(202.97,81.1) v1(203.2,179.1) v1(203.23,0.5) v1(203.99,81.1) v1(204.35,170.56) v1(204.37,80.21) v1(204.88,58.05) v1(204.88,56.72) v1(205.39,57.41) v1(205.5,171.24) v1(205.49,168.81) v1(205.68,80.34) v1(205.96,58.05) v1(205.96,56.72) v1(206.32,81.23) v1(206.85,44.27) v1(206.91,3.76) v1(206.91,2.49) v1(207.08,80.34) v1(207.59,81.23) v1(208.22,80.34) v1(208.57,0.5) v1(208.7,179.1) v1(208.73,81.23) v1(209.24,80.34) v1(209.58,93.67) v1(209.87,81.23) v1(211.99,3.76) v1(211.99,2.49) v1(213.39,171.9) v1(213.9,0.5) v1(214.2,179.1) v1(216.06,91.89) v1(216.06,91.31) v1(217.07,3.76) v1(217.07,2.49) v1(217.45,169.6) v1(218,169.27) v1(219.14,101.86) v1(219.23,0.5) v1(219.29,91.26) v1(219.59,102.31) v1(219.7,179.1) v1(219.93,170.74) v1(220.35,110.12) v1(220.35,109.48) v1(220.37,108.47) v1(220.37,107.83) v1(220.37,107.07) v1(220.44,96.42) v1(220.44,95.83) v1(220.5,98.75) v1(220.63,141.17) v1(220.63,140.47) v1(220.63,139.84) v1(220.72,128.66) v1(220.72,128.03) v1(220.72,127.44) v1(220.72,126.86) v1(220.72,125.85) v1(220.72,125.25) v1(220.72,122.98) v1(220.87,131.51) v1(220.86,130.86) v1(221.45,130.86) v1(221.45,131.51) v1(221.52,41.98) v1(225.2,179.1) v1(226.47,32.71) v1(226.47,27.63) v1(226.47,22.55) v1(226.47,17.47) v1(226.47,12.39) v1(227.74,32.71) v1(227.74,27.63) v1(227.74,22.55) v1(227.74,17.47) v1(227.74,12.39) v1(229.9,180.6) v1(229.9,175.45) v1(229.9,165.16) v1(229.9,160.01) v1(229.9,154.87) v1(229.9,149.72) v1(229.9,144.58) v1(229.9,139.43) v1(229.9,134.29) v1(229.9,129.14) v1(229.9,124) v1(229.9,113.7) v1(229.9,108.56) v1(229.9,103.41) v1(229.9,98.27) v1(229.9,87.98) v1(229.9,77.69) v1(229.9,72.54) v1(229.9,67.39) v1(229.9,62.25) v1(229.9,57.1) v1(229.9,51.96) v1(229.9,46.81) v1(229.9,41.67) v1(229.9,36.52) v1(229.9,31.38) v1(229.9,26.23) v1(229.9,21.08) v1(229.9,15.94) v1(229.9,10.79) v1(229.9,0.5) v3(108.96,25.43) v3(109.8,25.31) v3(110.5,25.31) v3(110.82,28.68) v3(111.45,28.68) v3(111.52,25.31) v3(112.28,25.31) v3(112.36,28.71) v3(112.93,144.41) v3(112.93,143.77) v3(112.94,142.76) v3(112.94,142) v3(112.94,141.23) v3(112.94,140.47) v3(112.94,139.71) v3(113,28.71) v3(113.57,144.41) v3(113.57,143.77) v3(113.64,142.76) v3(113.64,142) v3(113.64,141.23) v3(113.64,140.47) v3(113.64,139.71) v3(114.34,142.76) v3(114.34,142) v3(114.34,141.23) v3(114.34,140.47) v3(114.34,139.71) v3(116.74,144.09) v3(117.38,144.09) v3(118.01,144.09) v3(118.65,144.09) v3(121.14,17.95) v3(121.06,17.09) v3(121.63,16.65) v3(121.76,17.47) v3(122.33,16.9) v3(124.43,21.85) v3(124.43,21.22) v3(125.06,21.85) v3(125.06,21.22) v3(125.82,24) v3(125.82,23.37) v3(125.82,22.73) v3(125.82,22.1) v3(125.82,21.46) v3(126.46,24) v3(126.46,23.37) v3(126.46,22.73) v3(126.46,22.1) v3(126.46,21.46) v3(127.09,24) v3(127.09,23.37) v3(127.09,22.73) v3(127.09,22.1) v3(127.09,21.46) v3(127.41,15.71) v3(127.79,22.81) v3(127.79,22.17) v3(127.79,21.54) v3(128.24,164.92) v3(128.24,164.28) v3(128.25,24.55) v3(128.25,16.55) v3(128.25,15.71) v3(128.43,22.81) v3(128.43,22.17) v3(128.43,21.54) v3(128.87,164.92) v3(128.87,164.28) v3(128.91,24.55) v3(129.51,164.92) v3(129.51,164.28) v3(130.14,164.92) v3(130.14,164.28) v3(130.64,20.36) v3(130.78,164.92) v3(130.78,164.28) v3(130.97,139.01) v3(130.97,138.38) v3(130.97,137.74) v3(131.3,20.36) v3(131.6,139.01) v3(131.6,138.38) v3(131.6,137.74) v3(131.96,20.36) v3(133.43,16.99) v3(133.38,16.33) v3(134.84,139.19) v3(134.84,138.55) v3(134.84,137.92) v3(135.47,139.19) v3(135.47,138.55) v3(135.47,137.92) v3(137.7,189.49) v3(137.7,188.86) v3(137.7,188.22) v3(137.7,187.59) v3(137.7,186.95) v3(138.33,189.49) v3(138.33,188.86) v3(138.33,188.22) v3(138.33,187.59) v3(138.33,186.95) v3(138.97,187.27) v3(139.04,152.59) v3(139.29,154.24) v3(139.6,187.27) v3(139.67,152.59) v3(139.93,154.24) v3(140.31,152.59) v3(140.31,151.96) v3(140.31,151.32) v3(140.56,154.24) v3(140.62,144.92) v3(140.94,152.59) v3(140.94,151.96) v3(140.94,151.32) v3(141.2,154.24) v3(141.25,145.55) v3(141.25,144.92) v3(141.58,152.59) v3(141.58,151.96) v3(141.83,154.24) v3(141.89,145.55) v3(141.89,144.92) v3(142.21,152.59) v3(142.53,158.88) v3(143.42,158.88) v3(146.46,145.55) v3(146.46,144.92) v3(147.1,145.55) v3(147.1,144.92) v3(148.49,174.7) v3(148.49,174.06) v3(149.13,183.21) v3(149.13,182.57) v3(149.13,181.68) v3(149.13,181.05) v3(149.13,180.03) v3(149.13,179.4) v3(149.19,174.7) v3(149.19,174.06) v3(150.53,21.23) v3(150.53,20.6) v3(150.53,19.96) v3(151.17,21.23) v3(151.17,20.6) v3(151.17,19.96) v3(151.8,21.23) v3(151.8,20.6) v3(154.47,26.25) v3(155.1,26.25) v3(157.77,28.92) v3(157.77,28.28) v3(158.09,25.3) v3(158.09,24.53) v3(158.09,22.44) v3(158.09,21.8) v3(158.79,13.61) v3(158.79,12.98) v3(158.79,12.34) v3(158.91,25.3) v3(158.91,24.47) v3(159.42,13.61) v3(159.42,12.98) v3(159.42,12.34) v3(160.05,167.27) v3(160.06,13.61) v3(160.06,12.98) v3(160.06,12.34) v3(160.21,166.56) v3(160.2,165.66) v3(160.18,19.2) v3(160.75,174.25) v3(160.75,173.11) v3(160.75,172.1) v3(160.75,171.08) v3(160.68,167.27) v3(160.69,13.61) v3(160.69,12.98) v3(160.69,12.34) v3(160.85,166.56) v3(160.84,165.66) v3(160.88,19.2) v3(161,176.41) v3(161,162.7) v3(161,162.06) v3(161.32,167.27) v3(161.33,13.61) v3(161.33,12.98) v3(161.33,12.34) v3(161.38,174.25) v3(161.38,173.11) v3(161.38,172.1) v3(161.38,171.08) v3(161.48,166.56) v3(161.47,165.66) v3(161.64,176.41) v3(161.64,162.7) v3(161.64,162.06) v3(162.02,174.25) v3(162.02,173.11) v3(162.02,172.1) v3(161.95,166.13) v3(161.95,165.24) v3(161.96,13.61) v3(161.96,12.98) v3(161.96,12.34) v3(162.27,162.7) v3(162.27,162.06) v3(162.72,166.13) v3(162.72,165.24) v3(162.65,13.28) v3(162.65,12.58) v3(178.72,179.4) v3(178.72,178.76) v3(178.72,178.13) v3(178.72,177.49) v3(178.72,176.86) v3(180.31,178.7) v3(180.31,178.06) v3(180.31,177.43) v3(180.31,176.79) v3(180.37,179.33) v3(181,179.54) v3(181,178.9) v3(181,178.27) v3(181.45,174.51) v3(181.45,173.87) v3(181.45,173.24) v3(181.45,172.6) v3(181.45,171.97) v3(181.68,179.54) v3(181.68,178.9) v3(181.68,178.27) v3(182.08,174.51) v3(182.08,173.87) v3(182.08,173.24) v3(182.08,172.6) v3(182.08,171.97) v3(182.72,174.51) v3(182.72,173.87) v3(182.72,173.24) v3(182.72,172.6) v3(187.29,168.98) v3(187.29,168.35) v3(187.93,168.98) v3(187.93,168.35) v3(188.56,168.98) v3(188.56,168.35) v3(189.2,168.98) v3(189.2,168.35) v3(215.29,69.86) v3(215.29,68.84) v3(215.29,66.49) v3(215.29,65.73) v3(215.29,64.97) v3(215.29,64.21) v3(215.29,63.45) v3(215.29,62.75) v3(215.36,72.34) v3(215.36,71.57) v3(215.36,70.81) v3(215.55,74.5) v3(215.55,73.86) v3(215.55,73.1) v3(216.12,72.34) v3(216.12,71.57) v3(216.12,70.81) v3(216.12,69.86) v3(216.06,68.84) v3(216.06,68.02) v3(216.06,67.26) v3(216.06,66.49) v3(216.06,65.73) v3(216.06,64.97) v3(216.06,64.21) v3(216.06,63.45) v3(216.06,62.75) v3(216.06,62.05) v3(216.06,61.41) v3(216.25,74.24) v3(216.25,73.48) v3(216.82,68.84) v3(216.82,68.02) v3(216.82,67.26) v3(216.82,66.49) v3(216.82,65.73) v3(216.82,64.97) v3(216.82,64.21) v3(216.82,63.45) v3(216.88,74.56) v3(216.88,73.86) v3(216.88,73.1) v3(216.88,72.34) v3(216.88,71.57) v3(216.88,70.81) v3(216.88,69.86) v3(217.53,73.1) v3(217.53,72.34) v3(217.53,71.57) v3(217.53,70.81) v3(217.53,69.86) v3(217.53,68.84) v3(217.53,68.02) v3(217.53,67.26) v3(217.53,66.49) v3(217.53,65.73) v3(217.53,64.97) v3(217.53,64.21) v3(217.53,63.45) v4(29.79,20.59) v4(63.77,77.42) v4(91.33,137.43) v4(106.5,93.43) v4(110.88,26.5) v4(114,94.44) v4(115.52,141.23) v4(143.52,154.83) v4(144.48,145.62) v4(149.3,176.36) v4(154.25,134.13) v4(156.48,106.06) v4(159.72,174.26) v4(160.22,161.94) v4(164.03,159.53) v4(164.22,12.65) v4(179.85,158.26) v4(180.1,75.01) v4(182.13,175.28) v4(183.28,173.66) v4(183.78,159.02) v4(185.89,182.78) v4(187.66,158.58) v4(188.42,179.4) v4(201.41,80.22) v4(214.53,65.06) v4(217.63,73.99) v4(217.56,61.42) v4(221.45,108.74) v4(221.63,129.37) v4(222.14,133.75)
